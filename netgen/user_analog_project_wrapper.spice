* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C2 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C3 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C4 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C5 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z2 0.71fF
C6 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C7 pd_0/R pd_0/UP 0.45fF
C8 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C9 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C10 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C11 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C12 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C13 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/and_pd_0/Out1 0.18fF
C14 divider_1/tspc_0/Z2 divider_1/nor_1/B 0.40fF
C15 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C16 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C17 divider_2/tspc_1/Q divider_2/tspc_0/Z4 0.15fF
C18 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C19 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C20 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C21 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C22 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C23 pd_1/DOWN pd_1/R 0.36fF
C24 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C25 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C26 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C27 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C28 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C29 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/UP 0.11fF
C30 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C31 divider_1/mc2 divider_1/nor_0/B 0.06fF
C32 divider_0/nor_0/B divider_0/mc2 0.06fF
C33 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C34 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C35 divider_0/and_0/OUT divider_0/clk 0.04fF
C36 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C37 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C38 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C39 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C40 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/B 0.47fF
C41 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C42 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/tspc_r_1/Qbar 0.05fF
C43 divider_1/tspc_0/Z1 divider_1/tspc_1/Q 0.01fF
C44 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C45 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C46 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C47 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C48 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C49 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C50 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C51 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C52 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C53 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C54 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C55 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT 1.11fF
C56 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C57 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C58 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C59 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C60 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C61 divider_1/mc2 divider_1/and_0/A 0.16fF
C62 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C63 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C64 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C65 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C66 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C67 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C68 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/tspc_r_0/z5 0.02fF
C69 divider_2/Out divider_2/tspc_0/Z3 0.05fF
C70 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C71 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C72 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C73 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C74 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C75 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C76 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_1/Q 0.14fF
C77 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C78 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C79 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C80 io_clamp_low[1] io_clamp_high[1] 0.53fF
C81 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C82 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C83 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C84 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/tspc_r_0/Qbar1 0.01fF
C85 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C86 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C87 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C88 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C89 pll_full_1/pd_0/DOWN pll_full_1/pd_0/UP 4.58fF
C90 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C91 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C92 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C93 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C94 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C95 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C96 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C97 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C98 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C99 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C100 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C101 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/DOWN 0.11fF
C102 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C103 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C104 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C105 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C106 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C107 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C108 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C109 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C110 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C111 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C112 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C113 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C114 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C115 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Z3 0.38fF
C116 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C117 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C118 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C119 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C120 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C121 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C122 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C123 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C124 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C125 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C126 divider_0/and_0/A divider_0/and_0/B 0.18fF
C127 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C128 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C129 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C130 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z1 0.09fF
C131 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C132 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C133 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C134 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C135 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C136 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C137 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/R 0.30fF
C138 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/R 0.21fF
C139 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C140 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C141 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C142 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C143 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT3 0.26fF
C144 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C145 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Z3 0.03fF
C146 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z3 0.06fF
C147 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C148 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C149 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C150 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z1 0.03fF
C151 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C152 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C153 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/nor_0/A 0.03fF
C154 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C155 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C156 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C157 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C158 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C159 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/a_740_n680# 0.19fF
C160 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C161 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C162 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C163 pll_full_1/cp_0/a_1710_0# pll_full_1/pd_0/DOWN 0.04fF
C164 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C165 divider_2/tspc_0/Z3 divider_2/nor_1/B 0.38fF
C166 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C167 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C168 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z2 0.30fF
C169 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C170 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C171 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C172 divider_0/mc2 divider_0/nor_1/B 0.15fF
C173 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C174 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C175 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C176 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C177 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/R 0.29fF
C178 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C179 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C180 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DIV 0.65fF
C181 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C182 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C183 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z3 0.45fF
C184 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C185 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C186 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C187 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C188 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C189 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C190 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C191 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C192 pll_full_1/pd_0/R pll_full_1/pd_0/DOWN 0.36fF
C193 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C194 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C195 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C196 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C197 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C198 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C199 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z3 0.16fF
C200 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C201 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C202 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C203 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C204 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C205 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C206 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C207 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C208 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C209 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C210 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C211 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/tspc_r_1/Qbar 0.05fF
C212 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C213 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/REF 0.04fF
C214 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C215 divider_1/nor_1/B divider_1/tspc_0/a_630_n680# 0.35fF
C216 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C217 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C218 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C219 pd_1/R pd_1/REF 0.61fF
C220 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C221 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C222 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C223 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C224 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_2/Q 0.01fF
C225 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/a_630_n680# 0.35fF
C226 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C227 pll_full_0/cp_0/down pll_full_0/cp_0/a_1710_0# 0.32fF
C228 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C229 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C230 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/tspc_r_1/Qbar 0.02fF
C231 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C232 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C233 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C234 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C235 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z1 0.17fF
C236 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C237 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C238 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z3 0.65fF
C239 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C240 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C241 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C242 cp_0/upbar cp_0/down 0.02fF
C243 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C244 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C245 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C246 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C247 divider_2/nor_0/B divider_2/tspc_1/Z3 0.38fF
C248 divider_2/nor_1/B divider_2/tspc_0/Z4 0.22fF
C249 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C250 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C251 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C252 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C253 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C254 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C255 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C256 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C257 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C258 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C259 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C260 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C261 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C262 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C263 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C264 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C265 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C266 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C267 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C268 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C269 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C270 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C271 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C272 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C273 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C274 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C275 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C276 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C277 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C278 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C279 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C280 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C281 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C282 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C283 divider_1/nor_1/B divider_1/tspc_1/a_630_n680# 0.00fF
C284 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C285 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Qbar1 0.11fF
C286 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/Z3 0.65fF
C287 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C288 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C289 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Q 0.51fF
C290 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z4 0.36fF
C291 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z2 0.19fF
C292 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C293 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C294 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z3 0.25fF
C295 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C296 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C297 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C298 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C299 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C300 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C301 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C302 cp_0/a_1710_n2840# cp_0/out 0.61fF
C303 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C304 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C305 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C306 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C307 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C308 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C309 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C310 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C311 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C312 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C313 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C314 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C315 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C316 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C317 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C318 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C319 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C320 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C321 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C322 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C323 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/nor_0/A 0.01fF
C324 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z4 0.12fF
C325 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C326 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C327 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/R 0.21fF
C328 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C329 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C330 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C331 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C332 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C333 divider_2/tspc_1/Q divider_2/nor_1/B 0.22fF
C334 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C335 divider_0/mc2 divider_0/nor_0/A 0.04fF
C336 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C337 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C338 divider_2/mc2 divider_2/nor_0/A 0.04fF
C339 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C340 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C341 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C342 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C343 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C344 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C345 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C346 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C347 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C348 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C349 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C350 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C351 io_clamp_low[0] io_clamp_high[0] 0.53fF
C352 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C353 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C354 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C355 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C356 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C357 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C358 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C359 divider_2/nor_1/Z1 divider_2/nor_1/B 0.06fF
C360 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C361 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C362 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C363 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C364 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C365 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C366 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C367 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C368 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C369 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C370 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C371 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C372 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/UP 0.33fF
C373 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C374 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C375 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C376 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C377 divider_1/Out divider_1/tspc_0/a_630_n680# 0.04fF
C378 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C379 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C380 pd_0/DIV pd_0/R 0.51fF
C381 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C382 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C383 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C384 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C385 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C386 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C387 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C388 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C389 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C390 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C391 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C392 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z3 0.05fF
C393 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C394 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C395 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C396 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C397 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C398 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C399 divider_1/tspc_0/Z1 divider_1/tspc_0/Z4 0.00fF
C400 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C401 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C402 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C403 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C404 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/UP 0.06fF
C405 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C406 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C407 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C408 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C409 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C410 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C411 pll_full_0/pd_0/DOWN pll_full_0/pd_0/R 0.36fF
C412 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C413 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C414 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C415 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C416 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C417 divider_2/tspc_2/Q divider_2/tspc_2/a_630_n680# 0.04fF
C418 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_0/B 0.18fF
C419 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C420 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C421 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C422 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C423 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C424 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C425 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C426 divider_0/mc2 divider_0/and_0/B 0.20fF
C427 io_clamp_high[2] io_analog[6] 0.53fF
C428 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C429 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C430 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C431 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/Out 0.04fF
C432 divider_2/mc2 divider_2/and_0/B 0.20fF
C433 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C434 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C435 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C436 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C437 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C438 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C439 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C440 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C441 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C442 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C443 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C444 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C445 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C446 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/z5 0.20fF
C447 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C448 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C449 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C450 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z4 0.14fF
C451 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C452 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C453 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C454 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/IN 0.00fF
C455 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C456 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C457 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/Z3 0.05fF
C458 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C459 pll_full_1/divbuf_0/IN pll_full_1/divider_0/nor_1/B 0.27fF
C460 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C461 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C462 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C463 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C464 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C465 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/DOWN 0.21fF
C466 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C467 pd_0/DOWN pd_0/UP 0.46fF
C468 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C469 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C470 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C471 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C472 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C473 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C474 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C475 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C476 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C477 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C478 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C479 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C480 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C481 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C482 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C483 divider_2/Out divider_2/nor_1/B 0.22fF
C484 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/Out 0.08fF
C485 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C486 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C487 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C488 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C489 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C490 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C491 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C492 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C493 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C494 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C495 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C496 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C497 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C498 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C499 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C500 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C501 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C502 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C503 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C504 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/Out 0.11fF
C505 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C506 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C507 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_0/Z4 0.02fF
C508 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C509 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C510 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C511 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C512 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C513 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C514 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C515 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C516 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/R 0.02fF
C517 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C518 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C519 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z1 0.71fF
C520 divider_2/mc2 divider_2/nor_1/B 0.15fF
C521 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C522 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C523 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C524 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C525 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C526 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C527 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C528 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C529 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C530 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C531 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C532 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C533 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C534 divider_2/tspc_2/Q divider_2/tspc_1/Z2 0.14fF
C535 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C536 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C537 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C538 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C539 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C540 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z4 0.14fF
C541 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
C542 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C543 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C544 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C545 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C546 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C547 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C548 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C549 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C550 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C551 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C552 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C553 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C554 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C555 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C556 divider_2/tspc_2/Q divider_2/nor_0/A 0.55fF
C557 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C558 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C559 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C560 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C561 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C562 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C563 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C564 io_clamp_low[1] io_analog[5] 0.53fF
C565 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT 0.00fF
C566 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/DIV 0.12fF
C567 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C568 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C569 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C570 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/z5 0.03fF
C571 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C572 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C573 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C574 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C575 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C576 divider_1/nor_1/B divider_1/tspc_0/Z4 0.22fF
C577 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C578 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C579 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C580 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C581 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C582 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C583 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C584 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/nor_1/B 0.03fF
C585 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C586 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C587 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C588 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C589 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C590 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C591 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/DOWN 0.21fF
C592 divider_2/tspc_0/Z2 divider_2/tspc_0/Z3 0.16fF
C593 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C594 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C595 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C596 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C597 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C598 divider_2/tspc_1/Z1 divider_2/tspc_2/Q 0.01fF
C599 divider_2/nor_0/B divider_2/tspc_1/a_630_n680# 0.35fF
C600 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C601 cp_0/a_10_n50# cp_0/vbias 0.19fF
C602 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C603 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C604 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C605 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/switch_1/vin 0.19fF
C606 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C607 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C608 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C609 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C610 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C611 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C612 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C613 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C614 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C615 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C616 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C617 pd_0/R pd_0/REF 0.61fF
C618 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C619 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C620 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C621 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C622 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C623 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C624 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C625 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C626 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C627 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C628 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C629 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C630 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C631 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C632 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C633 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/UP 0.21fF
C634 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C635 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z4 0.12fF
C636 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C637 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C638 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/tspc_r_1/Z4 0.04fF
C639 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C640 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C641 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C642 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C643 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/switch_1/vin 0.19fF
C644 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divbuf_0/IN 0.04fF
C645 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C646 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C647 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C648 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C649 divider_1/Out divider_1/tspc_0/Z3 0.05fF
C650 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C651 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C652 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C653 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C654 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C655 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C656 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C657 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C658 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C659 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C660 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C661 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C662 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_740_n680# 0.21fF
C663 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C664 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C665 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C666 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C667 divider_2/tspc_0/Z2 divider_2/tspc_0/Z4 0.36fF
C668 pll_full_1/pd_0/DIV pll_full_1/pd_0/R 0.51fF
C669 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C670 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C671 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C672 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT5 0.02fF
C673 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT5 20.26fF
C674 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C675 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C676 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C677 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/IN 0.13fF
C678 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C679 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z3 0.05fF
C680 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C681 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C682 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C683 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C684 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C685 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C686 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C687 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C688 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C689 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C690 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z1 0.17fF
C691 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C692 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C693 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C694 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C695 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C696 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C697 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C698 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C699 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_0/B 0.20fF
C700 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C701 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C702 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C703 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C704 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C705 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C706 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C707 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C708 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C709 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C710 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C711 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C712 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C713 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C714 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C715 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C716 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C717 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Z1 0.06fF
C718 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C719 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C720 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C721 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C722 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C723 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C724 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C725 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C726 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C727 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C728 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C729 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C730 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C731 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C732 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C733 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C734 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C735 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C736 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C737 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C738 ro_complete_1/a4 ro_complete_1/cbank_0/switch_1/vin 0.09fF
C739 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C740 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C741 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C742 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C743 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C744 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C745 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C746 divider_1/tspc_0/Z1 divider_1/nor_1/B 0.03fF
C747 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C748 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C749 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C750 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C751 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/R 0.03fF
C752 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C753 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C754 pd_1/DIV pd_1/R 0.51fF
C755 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C756 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C757 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C758 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z4 0.20fF
C759 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C760 divider_2/tspc_1/Q divider_2/tspc_0/Z2 0.14fF
C761 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C762 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C763 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C764 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z1 1.07fF
C765 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C766 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C767 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C768 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C769 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C770 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C771 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C772 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C773 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C774 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C775 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C776 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C777 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C778 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C779 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C780 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C781 divider_2/tspc_0/Z1 divider_2/tspc_0/Z3 0.06fF
C782 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C783 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C784 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C785 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C786 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C787 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C788 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C789 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/pd_0/tspc_r_0/Z4 0.04fF
C790 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C791 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C792 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C793 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C794 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C795 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/REF 0.12fF
C796 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C797 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C798 divider_0/Out divider_0/nor_1/B 0.22fF
C799 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C800 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C801 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C802 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C803 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C804 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C805 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT 0.26fF
C806 pll_full_1/divbuf_1/OUT4 pll_full_1/divbuf_1/OUT5 20.26fF
C807 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C808 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z4 0.12fF
C809 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C810 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C811 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_0/A 0.15fF
C812 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C813 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C814 pll_full_1/cp_0/upbar pll_full_1/cp_0/down 0.02fF
C815 divider_1/tspc_1/Q divider_1/nor_0/B 0.51fF
C816 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C817 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C818 divider_1/nor_1/Z1 divider_1/nor_1/B 0.06fF
C819 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C820 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C821 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C822 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C823 pll_full_0/pd_0/UP pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C824 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_1/Q 0.01fF
C825 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C826 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C827 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C828 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C829 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C830 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C831 io_clamp_high[0] io_analog[4] 0.53fF
C832 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C833 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C834 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C835 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C836 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C837 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C838 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C839 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C840 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C841 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C842 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C843 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C844 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C845 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C846 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C847 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C848 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C849 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C850 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C851 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C852 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z4 0.02fF
C853 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C854 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C855 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C856 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C857 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C858 divider_2/tspc_0/Z1 divider_2/tspc_0/Z4 0.00fF
C859 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C860 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C861 pd_1/UP pd_1/tspc_r_1/Qbar 0.21fF
C862 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C863 divider_2/nor_0/B divider_2/tspc_0/Z4 0.02fF
C864 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C865 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C866 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C867 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C868 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C869 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C870 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C871 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C872 divider_1/mc2 divider_1/nor_0/A 0.04fF
C873 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C874 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C875 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C876 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C877 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/UP 0.03fF
C878 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C879 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C880 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C881 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C882 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C883 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C884 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C885 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C886 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C887 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C888 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C889 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C890 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C891 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C892 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C893 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C894 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C895 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C896 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C897 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C898 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C899 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z4 0.36fF
C900 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C901 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C902 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C903 pll_full_1/pd_0/R pll_full_1/pd_0/UP 0.46fF
C904 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C905 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C906 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C907 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C908 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/z5 0.11fF
C909 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C910 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C911 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C912 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/R 0.01fF
C913 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C914 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C915 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C916 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C917 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C918 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C919 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C920 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C921 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C922 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C923 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C924 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C925 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C926 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C927 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C928 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C929 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C930 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C931 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C932 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C933 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_630_n680# 0.04fF
C934 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C935 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z2 0.11fF
C936 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C937 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C938 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/a_740_n680# 0.19fF
C939 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C940 divider_2/tspc_1/Q divider_2/nor_0/B 0.51fF
C941 divider_1/mc2 divider_1/and_0/B 0.20fF
C942 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C943 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C944 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C945 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C946 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C947 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C948 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C949 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C950 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C951 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C952 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z3 0.06fF
C953 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C954 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C955 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C956 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C957 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C958 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C959 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C960 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C961 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C962 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C963 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C964 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C965 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C966 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C967 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C968 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C969 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C970 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C971 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C972 pd_1/DOWN pd_1/UP 0.46fF
C973 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Qbar1 0.20fF
C974 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C975 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C976 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C977 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Q 0.22fF
C978 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C979 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C980 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C981 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C982 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C983 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C984 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C985 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C986 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT2 0.42fF
C987 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/R 0.29fF
C988 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C989 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C990 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C991 divider_2/tspc_0/Z2 divider_2/nor_1/B 0.40fF
C992 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C993 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C994 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C995 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C996 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C997 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C998 divider_2/nor_0/B divider_2/tspc_1/Z2 0.30fF
C999 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C1000 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C1001 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C1002 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.00fF
C1003 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C1004 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1005 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1006 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C1007 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C1008 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1009 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C1010 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z2 0.25fF
C1011 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C1012 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1013 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1014 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1015 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C1016 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C1017 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1018 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1019 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C1020 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1021 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C1022 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/tspc_r_1/Z3 0.11fF
C1023 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C1024 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C1025 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C1026 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/IN 5.26fF
C1027 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C1028 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1029 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C1030 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C1031 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C1032 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1033 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C1034 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1035 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C1036 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1037 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1038 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1039 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C1040 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1041 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1042 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1043 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C1044 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1045 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1046 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C1047 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C1048 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Z2 0.21fF
C1049 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C1050 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1051 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C1052 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1053 pll_full_0/pd_0/REF pll_full_0/pd_0/R 0.61fF
C1054 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C1055 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C1056 divider_2/and_0/OUT divider_2/clk 0.04fF
C1057 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1058 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z4 0.00fF
C1059 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C1060 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1061 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1062 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C1063 divider_1/mc2 divider_1/nor_1/B 0.15fF
C1064 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C1065 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C1066 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C1067 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1068 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1069 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1070 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1071 divider_1/Out divider_1/nor_1/B 0.22fF
C1072 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C1073 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1074 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C1075 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C1076 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C1077 divider_2/nor_0/B divider_2/tspc_1/Z1 0.03fF
C1078 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C1079 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C1080 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/OUT2 0.42fF
C1081 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C1082 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C1083 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C1084 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z3 0.38fF
C1085 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C1086 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C1087 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C1088 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1089 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1090 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1091 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1092 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C1093 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C1094 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT3 5.16fF
C1095 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/UP 0.03fF
C1096 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1097 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C1098 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C1099 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C1100 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C1101 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C1102 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C1103 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C1104 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C1105 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z2 0.19fF
C1106 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C1107 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C1108 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1109 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1110 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1111 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1112 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C1113 pll_full_1/pd_0/REF pll_full_1/pd_0/DOWN 1.48fF
C1114 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Qbar 0.03fF
C1115 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C1116 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1117 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C1118 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C1119 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C1120 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C1121 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C1122 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C1123 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1124 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C1125 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C1126 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C1127 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C1128 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C1129 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C1130 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1131 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1132 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C1133 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C1134 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C1135 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C1136 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C1137 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1138 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C1139 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C1140 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1141 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1142 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C1143 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C1144 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C1145 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C1146 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1147 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1148 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C1149 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1150 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1151 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1152 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1153 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C1154 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C1155 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C1156 divider_2/and_0/A divider_2/and_0/B 0.18fF
C1157 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z2 0.01fF
C1158 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C1159 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1160 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1161 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1162 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1163 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1164 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1165 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C1166 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/REF 0.19fF
C1167 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C1168 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C1169 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1170 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1171 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1172 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C1173 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C1174 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1175 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C1176 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C1177 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1178 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C1179 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C1180 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C1181 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1182 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C1183 divider_1/tspc_1/Q divider_1/tspc_0/a_630_n680# 0.01fF
C1184 divider_0/mc2 divider_0/and_0/A 0.16fF
C1185 io_clamp_low[2] io_analog[6] 0.53fF
C1186 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/Qbar 0.01fF
C1187 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1188 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1189 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C1190 divider_2/mc2 divider_2/and_0/A 0.16fF
C1191 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z3 0.05fF
C1192 divider_1/nor_0/B divider_1/tspc_0/Z4 0.02fF
C1193 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C1194 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1195 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1196 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1197 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C1198 pll_full_0/cp_0/down pll_full_0/cp_0/upbar 0.02fF
C1199 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C1200 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C1201 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1202 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1203 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C1204 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1205 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C1206 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C1207 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C1208 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C1209 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1210 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1211 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1212 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/REF 0.65fF
C1213 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C1214 divider_2/tspc_0/Z1 divider_2/nor_1/B 0.03fF
C1215 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C1216 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C1217 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/z5 0.03fF
C1218 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C1219 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C1220 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1221 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C1222 divider_2/nor_0/B divider_2/nor_1/B 0.47fF
C1223 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a2 0.09fF
C1224 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C1225 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C1226 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C1227 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C1228 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1229 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C1230 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C1231 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C1232 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C1233 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1234 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C1235 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT3 0.01fF
C1236 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1237 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C1238 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C1239 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C1240 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C1241 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C1242 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a2 0.09fF
C1243 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C1244 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1245 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C1246 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C1247 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C1248 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C1249 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C1250 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1251 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1252 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1253 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C1254 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C1255 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C1256 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C1257 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1258 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z4 0.00fF
C1259 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C1260 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.01fF
C1261 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1262 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C1263 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C1264 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C1265 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C1266 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C1267 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C1268 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C1269 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C1270 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1271 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C1272 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1273 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/DIV 0.17fF
C1274 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1275 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z3 0.06fF
C1276 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C1277 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C1278 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C1279 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C1280 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C1281 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C1282 pd_1/R pd_1/UP 0.45fF
C1283 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C1284 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C1285 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1286 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C1287 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C1288 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C1289 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C1290 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C1291 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C1292 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1293 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C1294 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1295 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/z5 0.20fF
C1296 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1297 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1298 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C1299 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1300 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C1301 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1302 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1303 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C1304 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1305 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C1306 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C1307 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C1308 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1309 cp_0/a_1710_0# cp_0/out 0.84fF
C1310 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1311 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1312 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C1313 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_1/B 0.22fF
C1314 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1315 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1316 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1317 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C1318 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C1319 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C1320 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1321 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/z5 0.11fF
C1322 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C1323 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1324 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C1325 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C1326 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C1327 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C1328 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1329 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1330 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1331 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C1332 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C1333 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C1334 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1335 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C1336 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C1337 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C1338 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C1339 divider_1/tspc_0/Z2 divider_1/tspc_0/Z4 0.36fF
C1340 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1341 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C1342 divider_2/tspc_1/Q divider_2/tspc_0/a_630_n680# 0.01fF
C1343 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1344 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT5 0.01fF
C1345 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1346 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C1347 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C1348 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1349 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C1350 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C1351 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C1352 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1353 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z3 0.25fF
C1354 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1355 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C1356 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C1357 pll_full_0/pd_0/UP pll_full_0/pd_0/tspc_r_1/Qbar 0.21fF
C1358 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C1359 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1360 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1361 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C1362 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C1363 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C1364 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C1365 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C1366 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z3 0.05fF
C1367 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C1368 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1369 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1370 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/DOWN 0.12fF
C1371 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C1372 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1373 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C1374 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C1375 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1376 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C1377 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C1378 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C1379 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C1380 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C1381 divider_2/nor_0/B divider_2/tspc_2/Q 0.22fF
C1382 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1383 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1384 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C1385 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1386 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C1387 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C1388 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/DOWN 0.07fF
C1389 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1390 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C1391 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C1392 divider_1/and_0/OUT divider_1/clk 0.04fF
C1393 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C1394 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C1395 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C1396 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C1397 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1398 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C1399 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1400 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C1401 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C1402 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C1403 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C1404 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C1405 divider_2/tspc_1/Q divider_2/tspc_1/a_630_n680# 0.04fF
C1406 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1407 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C1408 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C1409 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C1410 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1411 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C1412 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C1413 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C1414 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C1415 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1416 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C1417 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/Out 0.19fF
C1418 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C1419 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DOWN 0.03fF
C1420 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C1421 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z3 0.05fF
C1422 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C1423 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C1424 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C1425 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C1426 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1427 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C1428 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C1429 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C1430 cp_0/a_1710_n2840# cp_0/a_1710_0# 0.83fF
C1431 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1432 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C1433 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C1434 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C1435 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C1436 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C1437 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1438 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C1439 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C1440 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C1441 pll_full_1/cp_0/down pll_full_1/cp_0/a_1710_0# 0.32fF
C1442 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1443 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C1444 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C1445 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C1446 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C1447 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1448 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C1449 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C1450 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1451 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C1452 pll_full_0/pd_0/DOWN pll_full_0/pd_0/REF 1.48fF
C1453 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1454 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C1455 pd_0/DOWN pd_0/R 0.36fF
C1456 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1457 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C1458 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C1459 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C1460 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1461 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1462 cp_0/a_1710_0# cp_0/down 0.32fF
C1463 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C1464 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_0/Z3 0.27fF
C1465 divider_2/tspc_1/a_630_n680# divider_2/tspc_1/Z2 0.01fF
C1466 divider_2/tspc_2/Q divider_2/tspc_1/Z3 0.45fF
C1467 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C1468 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1469 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1470 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C1471 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1472 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1473 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C1474 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C1475 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C1476 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C1477 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/R 0.30fF
C1478 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C1479 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1480 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1481 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1482 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C1483 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C1484 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1485 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1486 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1487 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1488 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1489 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C1490 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1491 io_clamp_low[2] io_clamp_high[2] 0.53fF
C1492 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C1493 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1494 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C1495 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1496 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C1497 io_clamp_high[1] io_analog[5] 0.53fF
C1498 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z3 0.16fF
C1499 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1500 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C1501 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1502 divider_2/Out divider_2/tspc_0/a_630_n680# 0.04fF
C1503 divider_1/and_0/A divider_1/and_0/B 0.18fF
C1504 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C1505 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1506 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C1507 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z3 0.45fF
C1508 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_1/B 0.40fF
C1509 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1510 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C1511 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C1512 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1513 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1514 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1515 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C1516 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1517 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1518 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C1519 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C1520 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z3 0.09fF
C1521 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C1522 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C1523 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C1524 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C1525 divider_2/tspc_0/Z3 divider_2/tspc_0/Z4 0.65fF
C1526 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C1527 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C1528 divider_1/tspc_0/Z2 divider_1/tspc_0/Z1 1.07fF
C1529 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/a5 0.09fF
C1530 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C1531 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C1532 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C1533 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1534 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1535 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C1536 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1537 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C1538 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C1539 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1540 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C1541 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C1542 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C1543 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C1544 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C1545 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C1546 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Qbar 0.01fF
C1547 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1548 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C1549 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1550 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C1551 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C1552 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1553 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C1554 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C1555 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C1556 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C1557 divider_1/nor_0/B divider_1/nor_1/B 0.47fF
C1558 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C1559 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C1560 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C1561 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1562 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C1563 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C1564 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1565 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1566 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1567 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1568 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C1569 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C1570 divider_1/tspc_0/Z4 divider_1/tspc_0/a_630_n680# 0.12fF
C1571 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C1572 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C1573 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1574 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C1575 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C1576 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1577 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C1578 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C1579 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C1580 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C1581 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C1582 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/pd_0/tspc_r_1/Z4 0.14fF
C1583 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C1584 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1585 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT 0.06fF
C1586 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT5 0.01fF
C1587 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1588 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C1589 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_0/Qbar1 0.01fF
C1590 divider_2/tspc_2/Q divider_2/tspc_1/Z4 0.15fF
C1591 divider_2/nor_1/B divider_2/tspc_0/a_630_n680# 0.35fF
C1592 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C1593 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C1594 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C1595 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z1 0.71fF
C1596 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1597 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1598 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1599 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1600 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1601 divider_2/tspc_1/Q divider_2/tspc_0/Z3 0.45fF
C1602 divider_1/mc2 divider_1/and_0/out1 0.06fF
C1603 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C1604 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1605 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/DOWN 0.02fF
C1606 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C1607 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1608 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C1609 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1610 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C1611 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1612 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1613 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C1614 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C1615 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C1616 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C1617 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C1618 divider_2/tspc_2/Q divider_2/tspc_2/Z3 0.05fF
C1619 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1620 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C1621 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C1622 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1623 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C1624 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C1625 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Z3 0.38fF
C1626 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C1627 io_clamp_low[0] io_analog[4] 0.53fF
C1628 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C1629 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1630 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C1631 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C1632 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C1633 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C1634 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C1635 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C1636 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C1637 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1638 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C1639 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C1640 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C1641 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1642 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C1643 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C1644 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1645 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C1646 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C1647 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C1648 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C1649 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1650 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1651 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C1652 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C1653 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C1654 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C1655 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C1656 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1657 divider_2/nor_1/B divider_2/tspc_1/a_630_n680# 0.00fF
C1658 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C1659 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C1660 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/DIV 0.19fF
C1661 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C1662 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
Xpd_0 VDD gnd pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 VDD gnd pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdd gnd cp_0/out cp_0/down cp_0/upbar cp
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivider_1 gnd vdd divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivider_2 gnd vdd divider_2/Out divider_2/clk divider_2/mc2 divider
Xpll_full_0 vdd pll_full
Xpll_full_1 vdd pll_full
C1663 io_analog[4] gnd 25.05fF
C1664 io_analog[5] gnd 25.05fF
C1665 io_analog[6] gnd 25.05fF
C1666 io_in_3v3[0] gnd 0.61fF
C1667 io_oeb[26] gnd 0.61fF
C1668 io_in[0] gnd 0.61fF
C1669 io_out[26] gnd 0.61fF
C1670 io_out[0] gnd 0.61fF
C1671 io_in[26] gnd 0.61fF
C1672 io_oeb[0] gnd 0.61fF
C1673 io_in_3v3[26] gnd 0.61fF
C1674 io_in_3v3[1] gnd 0.61fF
C1675 io_oeb[25] gnd 0.61fF
C1676 io_in[1] gnd 0.61fF
C1677 io_out[25] gnd 0.61fF
C1678 io_out[1] gnd 0.61fF
C1679 io_in[25] gnd 0.61fF
C1680 io_oeb[1] gnd 0.61fF
C1681 io_in_3v3[25] gnd 0.61fF
C1682 io_in_3v3[2] gnd 0.61fF
C1683 io_oeb[24] gnd 0.61fF
C1684 io_in[2] gnd 0.61fF
C1685 io_out[24] gnd 0.61fF
C1686 io_out[2] gnd 0.61fF
C1687 io_in[24] gnd 0.61fF
C1688 io_oeb[2] gnd 0.61fF
C1689 io_in_3v3[24] gnd 0.61fF
C1690 io_in_3v3[3] gnd 0.61fF
C1691 gpio_noesd[17] gnd 0.61fF
C1692 io_in[3] gnd 0.61fF
C1693 gpio_analog[17] gnd 0.61fF
C1694 io_out[3] gnd 0.61fF
C1695 io_oeb[3] gnd 0.61fF
C1696 io_in_3v3[4] gnd 0.61fF
C1697 io_in[4] gnd 0.61fF
C1698 io_out[4] gnd 0.61fF
C1699 io_oeb[4] gnd 0.61fF
C1700 io_oeb[23] gnd 0.61fF
C1701 io_out[23] gnd 0.61fF
C1702 io_in[23] gnd 0.61fF
C1703 io_in_3v3[23] gnd 0.61fF
C1704 gpio_noesd[16] gnd 0.61fF
C1705 gpio_analog[16] gnd 0.61fF
C1706 io_in_3v3[5] gnd 0.61fF
C1707 io_in[5] gnd 0.61fF
C1708 io_out[5] gnd 0.61fF
C1709 io_oeb[5] gnd 0.61fF
C1710 io_oeb[22] gnd 0.61fF
C1711 io_out[22] gnd 0.61fF
C1712 io_in[22] gnd 0.61fF
C1713 io_in_3v3[22] gnd 0.61fF
C1714 gpio_noesd[15] gnd 0.61fF
C1715 gpio_analog[15] gnd 0.61fF
C1716 io_in_3v3[6] gnd 0.61fF
C1717 io_in[6] gnd 0.61fF
C1718 io_out[6] gnd 0.61fF
C1719 io_oeb[6] gnd 0.61fF
C1720 io_oeb[21] gnd 0.61fF
C1721 io_out[21] gnd 0.61fF
C1722 io_in[21] gnd 0.61fF
C1723 io_in_3v3[21] gnd 0.61fF
C1724 gpio_noesd[14] gnd 0.61fF
C1725 gpio_analog[14] gnd 0.61fF
C1726 vssa1 gnd 26.08fF
C1727 vssd2 gnd 13.04fF
C1728 vssd1 gnd 13.04fF
C1729 vdda2 gnd 13.04fF
C1730 vdda1 gnd 26.08fF
C1731 io_oeb[20] gnd 0.61fF
C1732 io_out[20] gnd 0.61fF
C1733 io_in[20] gnd 0.61fF
C1734 io_in_3v3[20] gnd 0.61fF
C1735 gpio_noesd[13] gnd 0.61fF
C1736 gpio_analog[13] gnd 0.61fF
C1737 gpio_analog[0] gnd 0.61fF
C1738 gpio_noesd[0] gnd 0.61fF
C1739 io_in_3v3[7] gnd 0.61fF
C1740 io_in[7] gnd 0.61fF
C1741 io_out[7] gnd 0.61fF
C1742 io_oeb[7] gnd 0.61fF
C1743 io_oeb[19] gnd 0.61fF
C1744 io_out[19] gnd 0.61fF
C1745 io_in[19] gnd 0.61fF
C1746 io_in_3v3[19] gnd 0.61fF
C1747 gpio_noesd[12] gnd 0.61fF
C1748 gpio_analog[12] gnd 0.61fF
C1749 gpio_analog[1] gnd 0.61fF
C1750 gpio_noesd[1] gnd 0.61fF
C1751 io_in_3v3[8] gnd 0.61fF
C1752 io_in[8] gnd 0.61fF
C1753 io_out[8] gnd 0.61fF
C1754 io_oeb[8] gnd 0.61fF
C1755 io_oeb[18] gnd 0.61fF
C1756 io_out[18] gnd 0.61fF
C1757 io_in[18] gnd 0.61fF
C1758 io_in_3v3[18] gnd 0.61fF
C1759 gpio_noesd[11] gnd 0.61fF
C1760 gpio_analog[11] gnd 0.61fF
C1761 gpio_analog[2] gnd 0.61fF
C1762 gpio_noesd[2] gnd 0.61fF
C1763 io_in_3v3[9] gnd 0.61fF
C1764 io_in[9] gnd 0.61fF
C1765 io_out[9] gnd 0.61fF
C1766 io_oeb[9] gnd 0.61fF
C1767 io_oeb[17] gnd 0.61fF
C1768 io_out[17] gnd 0.61fF
C1769 io_in[17] gnd 0.61fF
C1770 io_in_3v3[17] gnd 0.61fF
C1771 gpio_noesd[10] gnd 0.61fF
C1772 gpio_analog[10] gnd 0.61fF
C1773 gpio_analog[3] gnd 0.61fF
C1774 gpio_noesd[3] gnd 0.61fF
C1775 io_in_3v3[10] gnd 0.61fF
C1776 io_in[10] gnd 0.61fF
C1777 io_out[10] gnd 0.61fF
C1778 io_oeb[10] gnd 0.61fF
C1779 io_oeb[16] gnd 0.61fF
C1780 io_out[16] gnd 0.61fF
C1781 io_in[16] gnd 0.61fF
C1782 io_in_3v3[16] gnd 0.61fF
C1783 gpio_noesd[9] gnd 0.61fF
C1784 gpio_analog[9] gnd 0.61fF
C1785 gpio_analog[4] gnd 0.61fF
C1786 gpio_noesd[4] gnd 0.61fF
C1787 io_in_3v3[11] gnd 0.61fF
C1788 io_in[11] gnd 0.61fF
C1789 io_out[11] gnd 0.61fF
C1790 io_oeb[11] gnd 0.61fF
C1791 io_oeb[15] gnd 0.61fF
C1792 io_out[15] gnd 0.61fF
C1793 io_in[15] gnd 0.61fF
C1794 io_in_3v3[15] gnd 0.61fF
C1795 gpio_noesd[8] gnd 0.61fF
C1796 gpio_analog[8] gnd 0.61fF
C1797 gpio_analog[5] gnd 0.61fF
C1798 gpio_noesd[5] gnd 0.61fF
C1799 io_in_3v3[12] gnd 0.61fF
C1800 io_in[12] gnd 0.61fF
C1801 io_out[12] gnd 0.61fF
C1802 io_oeb[12] gnd 0.61fF
C1803 io_oeb[14] gnd 0.61fF
C1804 io_out[14] gnd 0.61fF
C1805 io_in[14] gnd 0.61fF
C1806 io_in_3v3[14] gnd 0.61fF
C1807 gpio_noesd[7] gnd 0.61fF
C1808 gpio_analog[7] gnd 0.61fF
C1809 vssa2 gnd 13.04fF
C1810 gpio_analog[6] gnd 0.61fF
C1811 gpio_noesd[6] gnd 0.61fF
C1812 io_in_3v3[13] gnd 0.61fF
C1813 io_in[13] gnd 0.61fF
C1814 io_out[13] gnd 0.61fF
C1815 io_oeb[13] gnd 0.61fF
C1816 vccd1 gnd 13.04fF
C1817 vccd2 gnd 13.04fF
C1818 io_analog[0] gnd 6.83fF
C1819 io_analog[10] gnd 6.83fF
C1820 io_analog[1] gnd 6.83fF
C1821 io_analog[2] gnd 6.83fF
C1822 io_analog[3] gnd 6.83fF
C1823 io_clamp_high[0] gnd 3.58fF
C1824 io_clamp_low[0] gnd 3.58fF
C1825 io_clamp_high[1] gnd 3.58fF
C1826 io_clamp_low[1] gnd 3.58fF
C1827 io_clamp_high[2] gnd 3.58fF
C1828 io_clamp_low[2] gnd 3.58fF
C1829 io_analog[7] gnd 6.83fF
C1830 io_analog[8] gnd 6.83fF
C1831 io_analog[9] gnd 6.83fF
C1832 user_irq[2] gnd 0.63fF
C1833 user_irq[1] gnd 0.63fF
C1834 user_irq[0] gnd 0.63fF
C1835 user_clock2 gnd 0.63fF
C1836 la_oenb[127] gnd 0.63fF
C1837 la_data_out[127] gnd 0.63fF
C1838 la_data_in[127] gnd 0.63fF
C1839 la_oenb[126] gnd 0.63fF
C1840 la_data_out[126] gnd 0.63fF
C1841 la_data_in[126] gnd 0.63fF
C1842 la_oenb[125] gnd 0.63fF
C1843 la_data_out[125] gnd 0.63fF
C1844 la_data_in[125] gnd 0.63fF
C1845 la_oenb[124] gnd 0.63fF
C1846 la_data_out[124] gnd 0.63fF
C1847 la_data_in[124] gnd 0.63fF
C1848 la_oenb[123] gnd 0.63fF
C1849 la_data_out[123] gnd 0.63fF
C1850 la_data_in[123] gnd 0.63fF
C1851 la_oenb[122] gnd 0.63fF
C1852 la_data_out[122] gnd 0.63fF
C1853 la_data_in[122] gnd 0.63fF
C1854 la_oenb[121] gnd 0.63fF
C1855 la_data_out[121] gnd 0.63fF
C1856 la_data_in[121] gnd 0.63fF
C1857 la_oenb[120] gnd 0.63fF
C1858 la_data_out[120] gnd 0.63fF
C1859 la_data_in[120] gnd 0.63fF
C1860 la_oenb[119] gnd 0.63fF
C1861 la_data_out[119] gnd 0.63fF
C1862 la_data_in[119] gnd 0.63fF
C1863 la_oenb[118] gnd 0.63fF
C1864 la_data_out[118] gnd 0.63fF
C1865 la_data_in[118] gnd 0.63fF
C1866 la_oenb[117] gnd 0.63fF
C1867 la_data_out[117] gnd 0.63fF
C1868 la_data_in[117] gnd 0.63fF
C1869 la_oenb[116] gnd 0.63fF
C1870 la_data_out[116] gnd 0.63fF
C1871 la_data_in[116] gnd 0.63fF
C1872 la_oenb[115] gnd 0.63fF
C1873 la_data_out[115] gnd 0.63fF
C1874 la_data_in[115] gnd 0.63fF
C1875 la_oenb[114] gnd 0.63fF
C1876 la_data_out[114] gnd 0.63fF
C1877 la_data_in[114] gnd 0.63fF
C1878 la_oenb[113] gnd 0.63fF
C1879 la_data_out[113] gnd 0.63fF
C1880 la_data_in[113] gnd 0.63fF
C1881 la_oenb[112] gnd 0.63fF
C1882 la_data_out[112] gnd 0.63fF
C1883 la_data_in[112] gnd 0.63fF
C1884 la_oenb[111] gnd 0.63fF
C1885 la_data_out[111] gnd 0.63fF
C1886 la_data_in[111] gnd 0.63fF
C1887 la_oenb[110] gnd 0.63fF
C1888 la_data_out[110] gnd 0.63fF
C1889 la_data_in[110] gnd 0.63fF
C1890 la_oenb[109] gnd 0.63fF
C1891 la_data_out[109] gnd 0.63fF
C1892 la_data_in[109] gnd 0.63fF
C1893 la_oenb[108] gnd 0.63fF
C1894 la_data_out[108] gnd 0.63fF
C1895 la_data_in[108] gnd 0.63fF
C1896 la_oenb[107] gnd 0.63fF
C1897 la_data_out[107] gnd 0.63fF
C1898 la_data_in[107] gnd 0.63fF
C1899 la_oenb[106] gnd 0.63fF
C1900 la_data_out[106] gnd 0.63fF
C1901 la_data_in[106] gnd 0.63fF
C1902 la_oenb[105] gnd 0.63fF
C1903 la_data_out[105] gnd 0.63fF
C1904 la_data_in[105] gnd 0.63fF
C1905 la_oenb[104] gnd 0.63fF
C1906 la_data_out[104] gnd 0.63fF
C1907 la_data_in[104] gnd 0.63fF
C1908 la_oenb[103] gnd 0.63fF
C1909 la_data_out[103] gnd 0.63fF
C1910 la_data_in[103] gnd 0.63fF
C1911 la_oenb[102] gnd 0.63fF
C1912 la_data_out[102] gnd 0.63fF
C1913 la_data_in[102] gnd 0.63fF
C1914 la_oenb[101] gnd 0.63fF
C1915 la_data_out[101] gnd 0.63fF
C1916 la_data_in[101] gnd 0.63fF
C1917 la_oenb[100] gnd 0.63fF
C1918 la_data_out[100] gnd 0.63fF
C1919 la_data_in[100] gnd 0.63fF
C1920 la_oenb[99] gnd 0.63fF
C1921 la_data_out[99] gnd 0.63fF
C1922 la_data_in[99] gnd 0.63fF
C1923 la_oenb[98] gnd 0.63fF
C1924 la_data_out[98] gnd 0.63fF
C1925 la_data_in[98] gnd 0.63fF
C1926 la_oenb[97] gnd 0.63fF
C1927 la_data_out[97] gnd 0.63fF
C1928 la_data_in[97] gnd 0.63fF
C1929 la_oenb[96] gnd 0.63fF
C1930 la_data_out[96] gnd 0.63fF
C1931 la_data_in[96] gnd 0.63fF
C1932 la_oenb[95] gnd 0.63fF
C1933 la_data_out[95] gnd 0.63fF
C1934 la_data_in[95] gnd 0.63fF
C1935 la_oenb[94] gnd 0.63fF
C1936 la_data_out[94] gnd 0.63fF
C1937 la_data_in[94] gnd 0.63fF
C1938 la_oenb[93] gnd 0.63fF
C1939 la_data_out[93] gnd 0.63fF
C1940 la_data_in[93] gnd 0.63fF
C1941 la_oenb[92] gnd 0.63fF
C1942 la_data_out[92] gnd 0.63fF
C1943 la_data_in[92] gnd 0.63fF
C1944 la_oenb[91] gnd 0.63fF
C1945 la_data_out[91] gnd 0.63fF
C1946 la_data_in[91] gnd 0.63fF
C1947 la_oenb[90] gnd 0.63fF
C1948 la_data_out[90] gnd 0.63fF
C1949 la_data_in[90] gnd 0.63fF
C1950 la_oenb[89] gnd 0.63fF
C1951 la_data_out[89] gnd 0.63fF
C1952 la_data_in[89] gnd 0.63fF
C1953 la_oenb[88] gnd 0.63fF
C1954 la_data_out[88] gnd 0.63fF
C1955 la_data_in[88] gnd 0.63fF
C1956 la_oenb[87] gnd 0.63fF
C1957 la_data_out[87] gnd 0.63fF
C1958 la_data_in[87] gnd 0.63fF
C1959 la_oenb[86] gnd 0.63fF
C1960 la_data_out[86] gnd 0.63fF
C1961 la_data_in[86] gnd 0.63fF
C1962 la_oenb[85] gnd 0.63fF
C1963 la_data_out[85] gnd 0.63fF
C1964 la_data_in[85] gnd 0.63fF
C1965 la_oenb[84] gnd 0.63fF
C1966 la_data_out[84] gnd 0.63fF
C1967 la_data_in[84] gnd 0.63fF
C1968 la_oenb[83] gnd 0.63fF
C1969 la_data_out[83] gnd 0.63fF
C1970 la_data_in[83] gnd 0.63fF
C1971 la_oenb[82] gnd 0.63fF
C1972 la_data_out[82] gnd 0.63fF
C1973 la_data_in[82] gnd 0.63fF
C1974 la_oenb[81] gnd 0.63fF
C1975 la_data_out[81] gnd 0.63fF
C1976 la_data_in[81] gnd 0.63fF
C1977 la_oenb[80] gnd 0.63fF
C1978 la_data_out[80] gnd 0.63fF
C1979 la_data_in[80] gnd 0.63fF
C1980 la_oenb[79] gnd 0.63fF
C1981 la_data_out[79] gnd 0.63fF
C1982 la_data_in[79] gnd 0.63fF
C1983 la_oenb[78] gnd 0.63fF
C1984 la_data_out[78] gnd 0.63fF
C1985 la_data_in[78] gnd 0.63fF
C1986 la_oenb[77] gnd 0.63fF
C1987 la_data_out[77] gnd 0.63fF
C1988 la_data_in[77] gnd 0.63fF
C1989 la_oenb[76] gnd 0.63fF
C1990 la_data_out[76] gnd 0.63fF
C1991 la_data_in[76] gnd 0.63fF
C1992 la_oenb[75] gnd 0.63fF
C1993 la_data_out[75] gnd 0.63fF
C1994 la_data_in[75] gnd 0.63fF
C1995 la_oenb[74] gnd 0.63fF
C1996 la_data_out[74] gnd 0.63fF
C1997 la_data_in[74] gnd 0.63fF
C1998 la_oenb[73] gnd 0.63fF
C1999 la_data_out[73] gnd 0.63fF
C2000 la_data_in[73] gnd 0.63fF
C2001 la_oenb[72] gnd 0.63fF
C2002 la_data_out[72] gnd 0.63fF
C2003 la_data_in[72] gnd 0.63fF
C2004 la_oenb[71] gnd 0.63fF
C2005 la_data_out[71] gnd 0.63fF
C2006 la_data_in[71] gnd 0.63fF
C2007 la_oenb[70] gnd 0.63fF
C2008 la_data_out[70] gnd 0.63fF
C2009 la_data_in[70] gnd 0.63fF
C2010 la_oenb[69] gnd 0.63fF
C2011 la_data_out[69] gnd 0.63fF
C2012 la_data_in[69] gnd 0.63fF
C2013 la_oenb[68] gnd 0.63fF
C2014 la_data_out[68] gnd 0.63fF
C2015 la_data_in[68] gnd 0.63fF
C2016 la_oenb[67] gnd 0.63fF
C2017 la_data_out[67] gnd 0.63fF
C2018 la_data_in[67] gnd 0.63fF
C2019 la_oenb[66] gnd 0.63fF
C2020 la_data_out[66] gnd 0.63fF
C2021 la_data_in[66] gnd 0.63fF
C2022 la_oenb[65] gnd 0.63fF
C2023 la_data_out[65] gnd 0.63fF
C2024 la_data_in[65] gnd 0.63fF
C2025 la_oenb[64] gnd 0.63fF
C2026 la_data_out[64] gnd 0.63fF
C2027 la_data_in[64] gnd 0.63fF
C2028 la_oenb[63] gnd 0.63fF
C2029 la_data_out[63] gnd 0.63fF
C2030 la_data_in[63] gnd 0.63fF
C2031 la_oenb[62] gnd 0.63fF
C2032 la_data_out[62] gnd 0.63fF
C2033 la_data_in[62] gnd 0.63fF
C2034 la_oenb[61] gnd 0.63fF
C2035 la_data_out[61] gnd 0.63fF
C2036 la_data_in[61] gnd 0.63fF
C2037 la_oenb[60] gnd 0.63fF
C2038 la_data_out[60] gnd 0.63fF
C2039 la_data_in[60] gnd 0.63fF
C2040 la_oenb[59] gnd 0.63fF
C2041 la_data_out[59] gnd 0.63fF
C2042 la_data_in[59] gnd 0.63fF
C2043 la_oenb[58] gnd 0.63fF
C2044 la_data_out[58] gnd 0.63fF
C2045 la_data_in[58] gnd 0.63fF
C2046 la_oenb[57] gnd 0.63fF
C2047 la_data_out[57] gnd 0.63fF
C2048 la_data_in[57] gnd 0.63fF
C2049 la_oenb[56] gnd 0.63fF
C2050 la_data_out[56] gnd 0.63fF
C2051 la_data_in[56] gnd 0.63fF
C2052 la_oenb[55] gnd 0.63fF
C2053 la_data_out[55] gnd 0.63fF
C2054 la_data_in[55] gnd 0.63fF
C2055 la_oenb[54] gnd 0.63fF
C2056 la_data_out[54] gnd 0.63fF
C2057 la_data_in[54] gnd 0.63fF
C2058 la_oenb[53] gnd 0.63fF
C2059 la_data_out[53] gnd 0.63fF
C2060 la_data_in[53] gnd 0.63fF
C2061 la_oenb[52] gnd 0.63fF
C2062 la_data_out[52] gnd 0.63fF
C2063 la_data_in[52] gnd 0.63fF
C2064 la_oenb[51] gnd 0.63fF
C2065 la_data_out[51] gnd 0.63fF
C2066 la_data_in[51] gnd 0.63fF
C2067 la_oenb[50] gnd 0.63fF
C2068 la_data_out[50] gnd 0.63fF
C2069 la_data_in[50] gnd 0.63fF
C2070 la_oenb[49] gnd 0.63fF
C2071 la_data_out[49] gnd 0.63fF
C2072 la_data_in[49] gnd 0.63fF
C2073 la_oenb[48] gnd 0.63fF
C2074 la_data_out[48] gnd 0.63fF
C2075 la_data_in[48] gnd 0.63fF
C2076 la_oenb[47] gnd 0.63fF
C2077 la_data_out[47] gnd 0.63fF
C2078 la_data_in[47] gnd 0.63fF
C2079 la_oenb[46] gnd 0.63fF
C2080 la_data_out[46] gnd 0.63fF
C2081 la_data_in[46] gnd 0.63fF
C2082 la_oenb[45] gnd 0.63fF
C2083 la_data_out[45] gnd 0.63fF
C2084 la_data_in[45] gnd 0.63fF
C2085 la_oenb[44] gnd 0.63fF
C2086 la_data_out[44] gnd 0.63fF
C2087 la_data_in[44] gnd 0.63fF
C2088 la_oenb[43] gnd 0.63fF
C2089 la_data_out[43] gnd 0.63fF
C2090 la_data_in[43] gnd 0.63fF
C2091 la_oenb[42] gnd 0.63fF
C2092 la_data_out[42] gnd 0.63fF
C2093 la_data_in[42] gnd 0.63fF
C2094 la_oenb[41] gnd 0.63fF
C2095 la_data_out[41] gnd 0.63fF
C2096 la_data_in[41] gnd 0.63fF
C2097 la_oenb[40] gnd 0.63fF
C2098 la_data_out[40] gnd 0.63fF
C2099 la_data_in[40] gnd 0.63fF
C2100 la_oenb[39] gnd 0.63fF
C2101 la_data_out[39] gnd 0.63fF
C2102 la_data_in[39] gnd 0.63fF
C2103 la_oenb[38] gnd 0.63fF
C2104 la_data_out[38] gnd 0.63fF
C2105 la_data_in[38] gnd 0.63fF
C2106 la_oenb[37] gnd 0.63fF
C2107 la_data_out[37] gnd 0.63fF
C2108 la_data_in[37] gnd 0.63fF
C2109 la_oenb[36] gnd 0.63fF
C2110 la_data_out[36] gnd 0.63fF
C2111 la_data_in[36] gnd 0.63fF
C2112 la_oenb[35] gnd 0.63fF
C2113 la_data_out[35] gnd 0.63fF
C2114 la_data_in[35] gnd 0.63fF
C2115 la_oenb[34] gnd 0.63fF
C2116 la_data_out[34] gnd 0.63fF
C2117 la_data_in[34] gnd 0.63fF
C2118 la_oenb[33] gnd 0.63fF
C2119 la_data_out[33] gnd 0.63fF
C2120 la_data_in[33] gnd 0.63fF
C2121 la_oenb[32] gnd 0.63fF
C2122 la_data_out[32] gnd 0.63fF
C2123 la_data_in[32] gnd 0.63fF
C2124 la_oenb[31] gnd 0.63fF
C2125 la_data_out[31] gnd 0.63fF
C2126 la_data_in[31] gnd 0.63fF
C2127 la_oenb[30] gnd 0.63fF
C2128 la_data_out[30] gnd 0.63fF
C2129 la_data_in[30] gnd 0.63fF
C2130 la_oenb[29] gnd 0.63fF
C2131 la_data_out[29] gnd 0.63fF
C2132 la_data_in[29] gnd 0.63fF
C2133 la_oenb[28] gnd 0.63fF
C2134 la_data_out[28] gnd 0.63fF
C2135 la_data_in[28] gnd 0.63fF
C2136 la_oenb[27] gnd 0.63fF
C2137 la_data_out[27] gnd 0.63fF
C2138 la_data_in[27] gnd 0.63fF
C2139 la_oenb[26] gnd 0.63fF
C2140 la_data_out[26] gnd 0.63fF
C2141 la_data_in[26] gnd 0.63fF
C2142 la_oenb[25] gnd 0.63fF
C2143 la_data_out[25] gnd 0.63fF
C2144 la_data_in[25] gnd 0.63fF
C2145 la_oenb[24] gnd 0.63fF
C2146 la_data_out[24] gnd 0.63fF
C2147 la_data_in[24] gnd 0.63fF
C2148 la_oenb[23] gnd 0.63fF
C2149 la_data_out[23] gnd 0.63fF
C2150 la_data_in[23] gnd 0.63fF
C2151 la_oenb[22] gnd 0.63fF
C2152 la_data_out[22] gnd 0.63fF
C2153 la_data_in[22] gnd 0.63fF
C2154 la_oenb[21] gnd 0.63fF
C2155 la_data_out[21] gnd 0.63fF
C2156 la_data_in[21] gnd 0.63fF
C2157 la_oenb[20] gnd 0.63fF
C2158 la_data_out[20] gnd 0.63fF
C2159 la_data_in[20] gnd 0.63fF
C2160 la_oenb[19] gnd 0.63fF
C2161 la_data_out[19] gnd 0.63fF
C2162 la_data_in[19] gnd 0.63fF
C2163 la_oenb[18] gnd 0.63fF
C2164 la_data_out[18] gnd 0.63fF
C2165 la_data_in[18] gnd 0.63fF
C2166 la_oenb[17] gnd 0.63fF
C2167 la_data_out[17] gnd 0.63fF
C2168 la_data_in[17] gnd 0.63fF
C2169 la_oenb[16] gnd 0.63fF
C2170 la_data_out[16] gnd 0.63fF
C2171 la_data_in[16] gnd 0.63fF
C2172 la_oenb[15] gnd 0.63fF
C2173 la_data_out[15] gnd 0.63fF
C2174 la_data_in[15] gnd 0.63fF
C2175 la_oenb[14] gnd 0.63fF
C2176 la_data_out[14] gnd 0.63fF
C2177 la_data_in[14] gnd 0.63fF
C2178 la_oenb[13] gnd 0.63fF
C2179 la_data_out[13] gnd 0.63fF
C2180 la_data_in[13] gnd 0.63fF
C2181 la_oenb[12] gnd 0.63fF
C2182 la_data_out[12] gnd 0.63fF
C2183 la_data_in[12] gnd 0.63fF
C2184 la_oenb[11] gnd 0.63fF
C2185 la_data_out[11] gnd 0.63fF
C2186 la_data_in[11] gnd 0.63fF
C2187 la_oenb[10] gnd 0.63fF
C2188 la_data_out[10] gnd 0.63fF
C2189 la_data_in[10] gnd 0.63fF
C2190 la_oenb[9] gnd 0.63fF
C2191 la_data_out[9] gnd 0.63fF
C2192 la_data_in[9] gnd 0.63fF
C2193 la_oenb[8] gnd 0.63fF
C2194 la_data_out[8] gnd 0.63fF
C2195 la_data_in[8] gnd 0.63fF
C2196 la_oenb[7] gnd 0.63fF
C2197 la_data_out[7] gnd 0.63fF
C2198 la_data_in[7] gnd 0.63fF
C2199 la_oenb[6] gnd 0.63fF
C2200 la_data_out[6] gnd 0.63fF
C2201 la_data_in[6] gnd 0.63fF
C2202 la_oenb[5] gnd 0.63fF
C2203 la_data_out[5] gnd 0.63fF
C2204 la_data_in[5] gnd 0.63fF
C2205 la_oenb[4] gnd 0.63fF
C2206 la_data_out[4] gnd 0.63fF
C2207 la_data_in[4] gnd 0.63fF
C2208 la_oenb[3] gnd 0.63fF
C2209 la_data_out[3] gnd 0.63fF
C2210 la_data_in[3] gnd 0.63fF
C2211 la_oenb[2] gnd 0.63fF
C2212 la_data_out[2] gnd 0.63fF
C2213 la_data_in[2] gnd 0.63fF
C2214 la_oenb[1] gnd 0.63fF
C2215 la_data_out[1] gnd 0.63fF
C2216 la_data_in[1] gnd 0.63fF
C2217 la_oenb[0] gnd 0.63fF
C2218 la_data_out[0] gnd 0.63fF
C2219 la_data_in[0] gnd 0.63fF
C2220 wbs_dat_o[31] gnd 0.63fF
C2221 wbs_dat_i[31] gnd 0.63fF
C2222 wbs_adr_i[31] gnd 0.63fF
C2223 wbs_dat_o[30] gnd 0.63fF
C2224 wbs_dat_i[30] gnd 0.63fF
C2225 wbs_adr_i[30] gnd 0.63fF
C2226 wbs_dat_o[29] gnd 0.63fF
C2227 wbs_dat_i[29] gnd 0.63fF
C2228 wbs_adr_i[29] gnd 0.63fF
C2229 wbs_dat_o[28] gnd 0.63fF
C2230 wbs_dat_i[28] gnd 0.63fF
C2231 wbs_adr_i[28] gnd 0.63fF
C2232 wbs_dat_o[27] gnd 0.63fF
C2233 wbs_dat_i[27] gnd 0.63fF
C2234 wbs_adr_i[27] gnd 0.63fF
C2235 wbs_dat_o[26] gnd 0.63fF
C2236 wbs_dat_i[26] gnd 0.63fF
C2237 wbs_adr_i[26] gnd 0.63fF
C2238 wbs_dat_o[25] gnd 0.63fF
C2239 wbs_dat_i[25] gnd 0.63fF
C2240 wbs_adr_i[25] gnd 0.63fF
C2241 wbs_dat_o[24] gnd 0.63fF
C2242 wbs_dat_i[24] gnd 0.63fF
C2243 wbs_adr_i[24] gnd 0.63fF
C2244 wbs_dat_o[23] gnd 0.63fF
C2245 wbs_dat_i[23] gnd 0.63fF
C2246 wbs_adr_i[23] gnd 0.63fF
C2247 wbs_dat_o[22] gnd 0.63fF
C2248 wbs_dat_i[22] gnd 0.63fF
C2249 wbs_adr_i[22] gnd 0.63fF
C2250 wbs_dat_o[21] gnd 0.63fF
C2251 wbs_dat_i[21] gnd 0.63fF
C2252 wbs_adr_i[21] gnd 0.63fF
C2253 wbs_dat_o[20] gnd 0.63fF
C2254 wbs_dat_i[20] gnd 0.63fF
C2255 wbs_adr_i[20] gnd 0.63fF
C2256 wbs_dat_o[19] gnd 0.63fF
C2257 wbs_dat_i[19] gnd 0.63fF
C2258 wbs_adr_i[19] gnd 0.63fF
C2259 wbs_dat_o[18] gnd 0.63fF
C2260 wbs_dat_i[18] gnd 0.63fF
C2261 wbs_adr_i[18] gnd 0.63fF
C2262 wbs_dat_o[17] gnd 0.63fF
C2263 wbs_dat_i[17] gnd 0.63fF
C2264 wbs_adr_i[17] gnd 0.63fF
C2265 wbs_dat_o[16] gnd 0.63fF
C2266 wbs_dat_i[16] gnd 0.63fF
C2267 wbs_adr_i[16] gnd 0.63fF
C2268 wbs_dat_o[15] gnd 0.63fF
C2269 wbs_dat_i[15] gnd 0.63fF
C2270 wbs_adr_i[15] gnd 0.63fF
C2271 wbs_dat_o[14] gnd 0.63fF
C2272 wbs_dat_i[14] gnd 0.63fF
C2273 wbs_adr_i[14] gnd 0.63fF
C2274 wbs_dat_o[13] gnd 0.63fF
C2275 wbs_dat_i[13] gnd 0.63fF
C2276 wbs_adr_i[13] gnd 0.63fF
C2277 wbs_dat_o[12] gnd 0.63fF
C2278 wbs_dat_i[12] gnd 0.63fF
C2279 wbs_adr_i[12] gnd 0.63fF
C2280 wbs_dat_o[11] gnd 0.63fF
C2281 wbs_dat_i[11] gnd 0.63fF
C2282 wbs_adr_i[11] gnd 0.63fF
C2283 wbs_dat_o[10] gnd 0.63fF
C2284 wbs_dat_i[10] gnd 0.63fF
C2285 wbs_adr_i[10] gnd 0.63fF
C2286 wbs_dat_o[9] gnd 0.63fF
C2287 wbs_dat_i[9] gnd 0.63fF
C2288 wbs_adr_i[9] gnd 0.63fF
C2289 wbs_dat_o[8] gnd 0.63fF
C2290 wbs_dat_i[8] gnd 0.63fF
C2291 wbs_adr_i[8] gnd 0.63fF
C2292 wbs_dat_o[7] gnd 0.63fF
C2293 wbs_dat_i[7] gnd 0.63fF
C2294 wbs_adr_i[7] gnd 0.63fF
C2295 wbs_dat_o[6] gnd 0.63fF
C2296 wbs_dat_i[6] gnd 0.63fF
C2297 wbs_adr_i[6] gnd 0.63fF
C2298 wbs_dat_o[5] gnd 0.63fF
C2299 wbs_dat_i[5] gnd 0.63fF
C2300 wbs_adr_i[5] gnd 0.63fF
C2301 wbs_dat_o[4] gnd 0.63fF
C2302 wbs_dat_i[4] gnd 0.63fF
C2303 wbs_adr_i[4] gnd 0.63fF
C2304 wbs_sel_i[3] gnd 0.63fF
C2305 wbs_dat_o[3] gnd 0.63fF
C2306 wbs_dat_i[3] gnd 0.63fF
C2307 wbs_adr_i[3] gnd 0.63fF
C2308 wbs_sel_i[2] gnd 0.63fF
C2309 wbs_dat_o[2] gnd 0.63fF
C2310 wbs_dat_i[2] gnd 0.63fF
C2311 wbs_adr_i[2] gnd 0.63fF
C2312 wbs_sel_i[1] gnd 0.63fF
C2313 wbs_dat_o[1] gnd 0.63fF
C2314 wbs_dat_i[1] gnd 0.63fF
C2315 wbs_adr_i[1] gnd 0.63fF
C2316 wbs_sel_i[0] gnd 0.63fF
C2317 wbs_dat_o[0] gnd 0.63fF
C2318 wbs_dat_i[0] gnd 0.63fF
C2319 wbs_adr_i[0] gnd 0.63fF
C2320 wbs_we_i gnd 0.63fF
C2321 wbs_stb_i gnd 0.63fF
C2322 wbs_cyc_i gnd 0.63fF
C2323 wbs_ack_o gnd 0.63fF
C2324 wb_rst_i gnd 0.63fF
C2325 wb_clk_i gnd 0.63fF
C2326 pll_full_1/divider_0/and_0/Z1 gnd 0.65fF
C2327 pll_full_1/divider_0/and_0/B gnd 2.45fF
C2328 pll_full_1/divider_0/and_0/A gnd 2.35fF
C2329 pll_full_1/divider_0/and_0/out1 gnd 2.99fF
C2330 pll_full_1/divider_0/tspc_2/Z4 gnd 0.86fF
C2331 pll_full_1/divider_0/tspc_2/Z3 gnd 2.26fF
C2332 pll_full_1/divider_0/tspc_2/Z2 gnd 1.46fF
C2333 pll_full_1/divider_0/tspc_2/Z1 gnd 0.99fF
C2334 pll_full_1/divider_0/nor_0/A gnd 7.08fF
C2335 pll_full_1/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2336 pll_full_1/divider_0/tspc_1/Z4 gnd 0.86fF
C2337 pll_full_1/divider_0/tspc_1/Z3 gnd 2.26fF
C2338 pll_full_1/divider_0/tspc_1/Z2 gnd 1.46fF
C2339 pll_full_1/divider_0/tspc_1/Z1 gnd 0.99fF
C2340 pll_full_1/divider_0/nor_0/B gnd 7.12fF
C2341 pll_full_1/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2342 pll_full_1/divider_0/tspc_2/Q gnd 3.14fF
C2343 pll_full_1/divider_0/tspc_0/Z4 gnd 0.86fF
C2344 pll_full_1/divbuf_0/IN gnd 9.84fF
C2345 pll_full_1/divider_0/tspc_0/Z3 gnd 2.26fF
C2346 pll_full_1/divider_0/tspc_0/Z2 gnd 1.46fF
C2347 pll_full_1/divider_0/tspc_0/Z1 gnd 0.99fF
C2348 pll_full_1/divider_0/nor_1/B gnd 6.48fF
C2349 pll_full_1/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2350 pll_full_1/divider_0/tspc_1/Q gnd 3.12fF
C2351 pll_full_1/divider_0/clk gnd 33.42fF
C2352 pll_full_1/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2353 pll_full_1/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2354 pll_full_1/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2355 pll_full_1/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2356 pll_full_1/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2357 pll_full_1/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2358 pll_full_1/divider_0/and_0/OUT gnd 5.67fF
C2359 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2360 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2361 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2362 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2363 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2364 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2365 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2366 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2367 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2368 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2369 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2370 pll_full_1/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2371 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2372 pll_full_1/divider_0/prescaler_0/Out gnd 4.59fF
C2373 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2374 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2375 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2376 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2377 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2378 pll_full_1/divider_0/nor_1/Z1 gnd 1.34fF
C2379 pll_full_1/divider_0/nor_0/Z1 gnd 1.34fF
C2380 pll_full_1/divbuf_1/OUT gnd 363.82fF
C2381 pll_full_1/divbuf_1/OUT5 gnd 350.37fF
C2382 pll_full_1/divbuf_1/OUT4 gnd 133.72fF
C2383 pll_full_1/divbuf_1/OUT3 gnd 34.03fF
C2384 pll_full_1/divbuf_1/OUT2 gnd 8.71fF
C2385 pll_full_1/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2386 pll_full_1/divbuf_0/OUT5 gnd 350.37fF
C2387 pll_full_1/divbuf_0/OUT4 gnd 133.72fF
C2388 pll_full_1/divbuf_0/OUT3 gnd 34.03fF
C2389 pll_full_1/divbuf_0/OUT2 gnd 8.71fF
C2390 pll_full_1/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2391 pll_full_1/ro_complete_0/cbank_2/v gnd 16.43fF
C2392 pll_full_1/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2393 pll_full_1/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2394 pll_full_1/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2395 pll_full_1/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2396 pll_full_1/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2397 pll_full_1/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2398 pll_full_1/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2399 pll_full_1/ro_complete_0/a0 gnd 5.35fF
C2400 pll_full_1/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2401 pll_full_1/ro_complete_0/a1 gnd 6.54fF
C2402 pll_full_1/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2403 pll_full_1/ro_complete_0/a3 gnd 5.96fF
C2404 pll_full_1/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2405 pll_full_1/ro_complete_0/a2 gnd 5.21fF
C2406 pll_full_1/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2407 pll_full_1/ro_complete_0/a4 gnd 5.81fF
C2408 pll_full_1/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2409 pll_full_1/ro_complete_0/a5 gnd 6.74fF
C2410 pll_full_1/ro_complete_0/cbank_0/v gnd 15.12fF
C2411 pll_full_1/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2412 pll_full_1/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2413 pll_full_1/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2414 pll_full_1/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2415 pll_full_1/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2416 pll_full_1/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2417 pll_full_1/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2418 pll_full_1/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2419 pll_full_1/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2420 pll_full_1/cp_0/down gnd 1.54fF
C2421 pll_full_1/cp_0/upbar gnd 1.79fF
C2422 pll_full_1/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2423 pll_full_1/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2424 pll_full_1/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2425 pll_full_1/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2426 pll_full_1/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2427 pll_full_1/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2428 pll_full_1/pd_0/and_pd_0/Z1 gnd 0.39fF
C2429 pll_full_1/pd_0/and_pd_0/Out1 gnd 2.22fF
C2430 pll_full_1/pd_0/tspc_r_1/z5 gnd 1.10fF
C2431 pll_full_1/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2432 pll_full_1/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2433 pll_full_1/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2434 pll_full_1/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2435 pll_full_1/pd_0/UP gnd 6.41fF
C2436 pll_full_1/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2437 pll_full_1/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2438 pll_full_1/pd_0/REF gnd 6.48fF
C2439 pll_full_1/pd_0/tspc_r_0/z5 gnd 1.10fF
C2440 pll_full_1/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2441 pll_full_1/pd_0/R gnd 3.05fF
C2442 pll_full_1/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2443 pll_full_1/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2444 pll_full_1/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2445 pll_full_1/pd_0/DOWN gnd 7.34fF
C2446 pll_full_1/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2447 pll_full_1/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2448 pll_full_1/pd_0/DIV gnd 372.47fF
C2449 pll_full_0/divider_0/and_0/Z1 gnd 0.65fF
C2450 pll_full_0/divider_0/and_0/B gnd 2.45fF
C2451 pll_full_0/divider_0/and_0/A gnd 2.35fF
C2452 pll_full_0/divider_0/and_0/out1 gnd 2.99fF
C2453 pll_full_0/divider_0/tspc_2/Z4 gnd 0.86fF
C2454 pll_full_0/divider_0/tspc_2/Z3 gnd 2.26fF
C2455 pll_full_0/divider_0/tspc_2/Z2 gnd 1.46fF
C2456 pll_full_0/divider_0/tspc_2/Z1 gnd 0.99fF
C2457 pll_full_0/divider_0/nor_0/A gnd 7.08fF
C2458 pll_full_0/divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2459 pll_full_0/divider_0/tspc_1/Z4 gnd 0.86fF
C2460 pll_full_0/divider_0/tspc_1/Z3 gnd 2.26fF
C2461 pll_full_0/divider_0/tspc_1/Z2 gnd 1.46fF
C2462 pll_full_0/divider_0/tspc_1/Z1 gnd 0.99fF
C2463 pll_full_0/divider_0/nor_0/B gnd 7.12fF
C2464 pll_full_0/divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2465 pll_full_0/divider_0/tspc_2/Q gnd 3.14fF
C2466 pll_full_0/divider_0/tspc_0/Z4 gnd 0.86fF
C2467 pll_full_0/divbuf_0/IN gnd 9.84fF
C2468 pll_full_0/divider_0/tspc_0/Z3 gnd 2.26fF
C2469 pll_full_0/divider_0/tspc_0/Z2 gnd 1.46fF
C2470 pll_full_0/divider_0/tspc_0/Z1 gnd 0.99fF
C2471 pll_full_0/divider_0/nor_1/B gnd 6.48fF
C2472 pll_full_0/divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2473 pll_full_0/divider_0/tspc_1/Q gnd 3.12fF
C2474 pll_full_0/divider_0/clk gnd 33.42fF
C2475 pll_full_0/divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2476 pll_full_0/divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2477 pll_full_0/divider_0/prescaler_0/tspc_2/Q gnd 3.72fF
C2478 pll_full_0/divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2479 pll_full_0/divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2480 pll_full_0/divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2481 pll_full_0/divider_0/and_0/OUT gnd 5.67fF
C2482 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2483 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2484 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 gnd 1.19fF
C2485 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2486 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.47fF **FLOATING
C2487 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2488 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2489 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2490 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2491 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2492 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2493 pll_full_0/divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2494 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2495 pll_full_0/divider_0/prescaler_0/Out gnd 4.59fF
C2496 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2497 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2498 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2499 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2500 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2501 pll_full_0/divider_0/nor_1/Z1 gnd 1.34fF
C2502 pll_full_0/divider_0/nor_0/Z1 gnd 1.34fF
C2503 pll_full_0/divbuf_1/OUT gnd 363.82fF
C2504 pll_full_0/divbuf_1/OUT5 gnd 350.37fF
C2505 pll_full_0/divbuf_1/OUT4 gnd 133.72fF
C2506 pll_full_0/divbuf_1/OUT3 gnd 34.03fF
C2507 pll_full_0/divbuf_1/OUT2 gnd 8.71fF
C2508 pll_full_0/divbuf_1/a_492_n240# gnd 2.46fF **FLOATING
C2509 pll_full_0/divbuf_0/OUT5 gnd 350.37fF
C2510 pll_full_0/divbuf_0/OUT4 gnd 133.72fF
C2511 pll_full_0/divbuf_0/OUT3 gnd 34.03fF
C2512 pll_full_0/divbuf_0/OUT2 gnd 8.71fF
C2513 pll_full_0/divbuf_0/a_492_n240# gnd 2.46fF **FLOATING
C2514 pll_full_0/ro_complete_0/cbank_2/v gnd 16.43fF
C2515 pll_full_0/ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2516 pll_full_0/ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2517 pll_full_0/ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2518 pll_full_0/ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2519 pll_full_0/ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2520 pll_full_0/ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2521 pll_full_0/ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2522 pll_full_0/ro_complete_0/a0 gnd 5.35fF
C2523 pll_full_0/ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2524 pll_full_0/ro_complete_0/a1 gnd 6.54fF
C2525 pll_full_0/ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2526 pll_full_0/ro_complete_0/a3 gnd 5.96fF
C2527 pll_full_0/ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2528 pll_full_0/ro_complete_0/a2 gnd 5.21fF
C2529 pll_full_0/ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2530 pll_full_0/ro_complete_0/a4 gnd 5.81fF
C2531 pll_full_0/ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2532 pll_full_0/ro_complete_0/a5 gnd 6.74fF
C2533 pll_full_0/ro_complete_0/cbank_0/v gnd 15.12fF
C2534 pll_full_0/ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2535 pll_full_0/ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2536 pll_full_0/ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2537 pll_full_0/ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2538 pll_full_0/ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2539 pll_full_0/ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2540 pll_full_0/ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2541 pll_full_0/filter_0/a_4216_n5230# gnd 418.90fF **FLOATING
C2542 pll_full_0/filter_0/a_4216_n2998# gnd 1.39fF **FLOATING
C2543 pll_full_0/cp_0/down gnd 1.54fF
C2544 pll_full_0/cp_0/upbar gnd 1.79fF
C2545 pll_full_0/cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2546 pll_full_0/cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2547 pll_full_0/cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2548 pll_full_0/cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2549 pll_full_0/cp_0/a_3060_0# gnd 2.49fF **FLOATING
C2550 pll_full_0/cp_0/a_1710_0# gnd 7.47fF **FLOATING
C2551 pll_full_0/pd_0/and_pd_0/Z1 gnd 0.39fF
C2552 pll_full_0/pd_0/and_pd_0/Out1 gnd 2.22fF
C2553 pll_full_0/pd_0/tspc_r_1/z5 gnd 1.10fF
C2554 pll_full_0/pd_0/tspc_r_1/Z4 gnd 1.07fF
C2555 pll_full_0/pd_0/tspc_r_1/Qbar gnd 0.88fF
C2556 pll_full_0/pd_0/tspc_r_1/Z2 gnd 1.22fF
C2557 pll_full_0/pd_0/tspc_r_1/Z1 gnd 0.67fF
C2558 pll_full_0/pd_0/UP gnd 6.41fF
C2559 pll_full_0/pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2560 pll_full_0/pd_0/tspc_r_1/Z3 gnd 2.12fF
C2561 pll_full_0/pd_0/REF gnd 6.48fF
C2562 pll_full_0/pd_0/tspc_r_0/z5 gnd 1.10fF
C2563 pll_full_0/pd_0/tspc_r_0/Z4 gnd 1.07fF
C2564 pll_full_0/pd_0/R gnd 3.05fF
C2565 pll_full_0/pd_0/tspc_r_0/Qbar gnd 0.79fF
C2566 pll_full_0/pd_0/tspc_r_0/Z2 gnd 1.22fF
C2567 pll_full_0/pd_0/tspc_r_0/Z1 gnd 0.67fF
C2568 pll_full_0/pd_0/DOWN gnd 7.34fF
C2569 pll_full_0/pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2570 pll_full_0/pd_0/tspc_r_0/Z3 gnd 2.12fF
C2571 pll_full_0/pd_0/DIV gnd 372.47fF
C2572 divider_2/and_0/Z1 gnd 0.74fF
C2573 divider_2/and_0/B gnd 2.25fF
C2574 divider_2/and_0/A gnd 2.19fF
C2575 divider_2/and_0/out1 gnd 2.93fF
C2576 divider_2/tspc_2/Z4 gnd 0.86fF
C2577 divider_2/tspc_2/Z3 gnd 2.26fF
C2578 divider_2/tspc_2/Z2 gnd 1.46fF
C2579 divider_2/tspc_2/Z1 gnd 0.99fF
C2580 divider_2/nor_0/A gnd 7.04fF
C2581 divider_2/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2582 divider_2/tspc_1/Z4 gnd 0.86fF
C2583 divider_2/tspc_1/Z3 gnd 2.26fF
C2584 divider_2/tspc_1/Z2 gnd 1.46fF
C2585 divider_2/tspc_1/Z1 gnd 0.99fF
C2586 divider_2/nor_0/B gnd 7.05fF
C2587 divider_2/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2588 divider_2/tspc_2/Q gnd 3.14fF
C2589 divider_2/tspc_0/Z4 gnd 0.86fF
C2590 divider_2/Out gnd 1.60fF
C2591 divider_2/tspc_0/Z3 gnd 2.26fF
C2592 divider_2/tspc_0/Z2 gnd 1.46fF
C2593 divider_2/tspc_0/Z1 gnd 0.99fF
C2594 divider_2/nor_1/B gnd 6.33fF
C2595 divider_2/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2596 divider_2/tspc_1/Q gnd 3.12fF
C2597 divider_2/clk gnd 5.63fF
C2598 divider_2/prescaler_0/nand_1/z1 gnd 0.36fF
C2599 divider_2/prescaler_0/tspc_0/D gnd 2.64fF
C2600 divider_2/prescaler_0/tspc_2/Q gnd 3.64fF
C2601 divider_2/prescaler_0/tspc_1/Q gnd 3.61fF
C2602 divider_2/prescaler_0/nand_0/z1 gnd 0.36fF
C2603 divider_2/prescaler_0/tspc_2/D gnd 3.12fF
C2604 divider_2/and_0/OUT gnd 5.62fF
C2605 divider_2/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2606 divider_2/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2607 divider_2/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2608 divider_2/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2609 divider_2/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2610 divider_2/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2611 divider_2/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2612 divider_2/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2613 divider_2/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2614 divider_2/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2615 divider_2/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2616 divider_2/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2617 divider_2/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2618 divider_2/prescaler_0/Out gnd 4.59fF
C2619 divider_2/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2620 divider_2/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2621 divider_2/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2622 divider_2/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2623 divider_2/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2624 divider_2/nor_1/Z1 gnd 1.34fF
C2625 divider_2/mc2 gnd 5.29fF
C2626 divider_2/nor_0/Z1 gnd 1.34fF
C2627 divider_1/and_0/Z1 gnd 0.74fF
C2628 divider_1/and_0/B gnd 2.25fF
C2629 divider_1/and_0/A gnd 2.19fF
C2630 divider_1/and_0/out1 gnd 2.93fF
C2631 divider_1/tspc_2/Z4 gnd 0.86fF
C2632 divider_1/tspc_2/Z3 gnd 2.26fF
C2633 divider_1/tspc_2/Z2 gnd 1.46fF
C2634 divider_1/tspc_2/Z1 gnd 0.99fF
C2635 divider_1/nor_0/A gnd 7.04fF
C2636 divider_1/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2637 divider_1/tspc_1/Z4 gnd 0.86fF
C2638 divider_1/tspc_1/Z3 gnd 2.26fF
C2639 divider_1/tspc_1/Z2 gnd 1.46fF
C2640 divider_1/tspc_1/Z1 gnd 0.99fF
C2641 divider_1/nor_0/B gnd 7.05fF
C2642 divider_1/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2643 divider_1/tspc_2/Q gnd 3.14fF
C2644 divider_1/tspc_0/Z4 gnd 0.86fF
C2645 divider_1/Out gnd 1.60fF
C2646 divider_1/tspc_0/Z3 gnd 2.26fF
C2647 divider_1/tspc_0/Z2 gnd 1.46fF
C2648 divider_1/tspc_0/Z1 gnd 0.99fF
C2649 divider_1/nor_1/B gnd 6.33fF
C2650 divider_1/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2651 divider_1/tspc_1/Q gnd 3.12fF
C2652 divider_1/clk gnd 5.63fF
C2653 divider_1/prescaler_0/nand_1/z1 gnd 0.36fF
C2654 divider_1/prescaler_0/tspc_0/D gnd 2.64fF
C2655 divider_1/prescaler_0/tspc_2/Q gnd 3.64fF
C2656 divider_1/prescaler_0/tspc_1/Q gnd 3.61fF
C2657 divider_1/prescaler_0/nand_0/z1 gnd 0.36fF
C2658 divider_1/prescaler_0/tspc_2/D gnd 3.12fF
C2659 divider_1/and_0/OUT gnd 5.62fF
C2660 divider_1/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2661 divider_1/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2662 divider_1/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2663 divider_1/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2664 divider_1/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2665 divider_1/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2666 divider_1/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2667 divider_1/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2668 divider_1/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2669 divider_1/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2670 divider_1/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2671 divider_1/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2672 divider_1/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2673 divider_1/prescaler_0/Out gnd 4.59fF
C2674 divider_1/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2675 divider_1/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2676 divider_1/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2677 divider_1/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2678 divider_1/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2679 divider_1/nor_1/Z1 gnd 1.34fF
C2680 divider_1/mc2 gnd 5.29fF
C2681 divider_1/nor_0/Z1 gnd 1.34fF
C2682 divider_0/and_0/Z1 gnd 0.74fF
C2683 divider_0/and_0/B gnd 2.25fF
C2684 divider_0/and_0/A gnd 2.19fF
C2685 divider_0/and_0/out1 gnd 2.93fF
C2686 divider_0/tspc_2/Z4 gnd 0.86fF
C2687 divider_0/tspc_2/Z3 gnd 2.26fF
C2688 divider_0/tspc_2/Z2 gnd 1.46fF
C2689 divider_0/tspc_2/Z1 gnd 0.99fF
C2690 divider_0/nor_0/A gnd 7.04fF
C2691 divider_0/tspc_2/a_630_n680# gnd 1.15fF **FLOATING
C2692 divider_0/tspc_1/Z4 gnd 0.86fF
C2693 divider_0/tspc_1/Z3 gnd 2.26fF
C2694 divider_0/tspc_1/Z2 gnd 1.46fF
C2695 divider_0/tspc_1/Z1 gnd 0.99fF
C2696 divider_0/nor_0/B gnd 7.05fF
C2697 divider_0/tspc_1/a_630_n680# gnd 1.15fF **FLOATING
C2698 divider_0/tspc_2/Q gnd 3.14fF
C2699 divider_0/tspc_0/Z4 gnd 0.86fF
C2700 divider_0/Out gnd 1.60fF
C2701 divider_0/tspc_0/Z3 gnd 2.26fF
C2702 divider_0/tspc_0/Z2 gnd 1.46fF
C2703 divider_0/tspc_0/Z1 gnd 0.99fF
C2704 divider_0/nor_1/B gnd 6.33fF
C2705 divider_0/tspc_0/a_630_n680# gnd 1.14fF **FLOATING
C2706 divider_0/tspc_1/Q gnd 3.12fF
C2707 divider_0/clk gnd 5.63fF
C2708 divider_0/prescaler_0/nand_1/z1 gnd 0.36fF
C2709 divider_0/prescaler_0/tspc_0/D gnd 2.64fF
C2710 divider_0/prescaler_0/tspc_2/Q gnd 3.64fF
C2711 divider_0/prescaler_0/tspc_1/Q gnd 3.61fF
C2712 divider_0/prescaler_0/nand_0/z1 gnd 0.36fF
C2713 divider_0/prescaler_0/tspc_2/D gnd 3.12fF
C2714 divider_0/and_0/OUT gnd 5.62fF
C2715 divider_0/prescaler_0/tspc_2/Z4 gnd 0.86fF
C2716 divider_0/prescaler_0/tspc_2/Z3 gnd 2.26fF
C2717 divider_0/prescaler_0/tspc_2/Z2 gnd 1.46fF
C2718 divider_0/prescaler_0/tspc_2/Z1 gnd 0.99fF
C2719 divider_0/prescaler_0/tspc_2/a_630_n680# gnd 1.14fF **FLOATING
C2720 divider_0/prescaler_0/tspc_2/a_740_n680# gnd 2.11fF **FLOATING
C2721 divider_0/prescaler_0/tspc_1/Z4 gnd 0.86fF
C2722 divider_0/prescaler_0/tspc_1/Z3 gnd 2.26fF
C2723 divider_0/prescaler_0/tspc_1/Z2 gnd 1.48fF
C2724 divider_0/prescaler_0/tspc_1/Z1 gnd 0.99fF
C2725 divider_0/prescaler_0/tspc_1/a_630_n680# gnd 1.14fF **FLOATING
C2726 divider_0/prescaler_0/m1_2700_2190# gnd 4.22fF **FLOATING
C2727 divider_0/prescaler_0/tspc_0/Z4 gnd 0.86fF
C2728 divider_0/prescaler_0/Out gnd 4.59fF
C2729 divider_0/prescaler_0/tspc_0/Z3 gnd 2.26fF
C2730 divider_0/prescaler_0/tspc_0/Z2 gnd 1.46fF
C2731 divider_0/prescaler_0/tspc_0/Z1 gnd 0.99fF
C2732 divider_0/prescaler_0/tspc_0/a_630_n680# gnd 1.16fF **FLOATING
C2733 divider_0/prescaler_0/tspc_0/a_740_n680# gnd 2.11fF **FLOATING
C2734 divider_0/nor_1/Z1 gnd 1.34fF
C2735 divider_0/mc2 gnd 5.29fF
C2736 divider_0/nor_0/Z1 gnd 1.34fF
C2737 ro_complete_1/cbank_2/v gnd 16.43fF
C2738 ro_complete_1/cbank_2/switch_5/vin gnd 0.78fF
C2739 ro_complete_1/cbank_2/switch_4/vin gnd 1.50fF
C2740 ro_complete_1/cbank_2/switch_2/vin gnd 1.30fF
C2741 ro_complete_1/cbank_2/switch_3/vin gnd 0.56fF
C2742 ro_complete_1/cbank_2/switch_1/vin gnd 1.14fF
C2743 ro_complete_1/cbank_2/switch_0/vin gnd 1.02fF
C2744 ro_complete_1/cbank_1/v gnd 16.43fF
C2745 ro_complete_1/cbank_1/switch_5/vin gnd 0.78fF
C2746 ro_complete_1/a0 gnd 5.35fF
C2747 ro_complete_1/cbank_1/switch_4/vin gnd 1.50fF
C2748 ro_complete_1/a1 gnd 6.54fF
C2749 ro_complete_1/cbank_1/switch_2/vin gnd 1.30fF
C2750 ro_complete_1/a3 gnd 5.96fF
C2751 ro_complete_1/cbank_1/switch_3/vin gnd 0.56fF
C2752 ro_complete_1/a2 gnd 5.21fF
C2753 ro_complete_1/cbank_1/switch_1/vin gnd 1.14fF
C2754 ro_complete_1/a4 gnd 5.81fF
C2755 ro_complete_1/cbank_1/switch_0/vin gnd 1.02fF
C2756 ro_complete_1/a5 gnd 6.74fF
C2757 ro_complete_1/cbank_0/v gnd 15.12fF
C2758 ro_complete_1/cbank_0/switch_5/vin gnd 0.78fF
C2759 ro_complete_1/cbank_0/switch_4/vin gnd 1.50fF
C2760 ro_complete_1/cbank_0/switch_2/vin gnd 1.30fF
C2761 ro_complete_1/cbank_0/switch_3/vin gnd 0.56fF
C2762 ro_complete_1/cbank_0/switch_1/vin gnd 1.14fF
C2763 ro_complete_1/cbank_0/switch_0/vin gnd 1.02fF
C2764 ro_complete_1/ro_var_extend_0/vcont gnd 0.27fF
C2765 ro_complete_0/cbank_2/v gnd 16.43fF
C2766 ro_complete_0/cbank_2/switch_5/vin gnd 0.78fF
C2767 ro_complete_0/cbank_2/switch_4/vin gnd 1.50fF
C2768 ro_complete_0/cbank_2/switch_2/vin gnd 1.30fF
C2769 ro_complete_0/cbank_2/switch_3/vin gnd 0.56fF
C2770 ro_complete_0/cbank_2/switch_1/vin gnd 1.14fF
C2771 ro_complete_0/cbank_2/switch_0/vin gnd 1.02fF
C2772 ro_complete_0/cbank_1/v gnd 16.43fF
C2773 ro_complete_0/cbank_1/switch_5/vin gnd 0.78fF
C2774 ro_complete_0/a0 gnd 5.35fF
C2775 ro_complete_0/cbank_1/switch_4/vin gnd 1.50fF
C2776 ro_complete_0/a1 gnd 6.54fF
C2777 ro_complete_0/cbank_1/switch_2/vin gnd 1.30fF
C2778 ro_complete_0/a3 gnd 5.96fF
C2779 ro_complete_0/cbank_1/switch_3/vin gnd 0.56fF
C2780 ro_complete_0/a2 gnd 5.21fF
C2781 ro_complete_0/cbank_1/switch_1/vin gnd 1.14fF
C2782 ro_complete_0/a4 gnd 5.81fF
C2783 ro_complete_0/cbank_1/switch_0/vin gnd 1.02fF
C2784 ro_complete_0/a5 gnd 6.74fF
C2785 ro_complete_0/cbank_0/v gnd 15.12fF
C2786 ro_complete_0/cbank_0/switch_5/vin gnd 0.78fF
C2787 ro_complete_0/cbank_0/switch_4/vin gnd 1.50fF
C2788 ro_complete_0/cbank_0/switch_2/vin gnd 1.30fF
C2789 ro_complete_0/cbank_0/switch_3/vin gnd 0.56fF
C2790 ro_complete_0/cbank_0/switch_1/vin gnd 1.14fF
C2791 ro_complete_0/cbank_0/switch_0/vin gnd 1.02fF
C2792 ro_complete_0/ro_var_extend_0/vcont gnd 0.27fF
C2793 cp_0/down gnd 1.54fF
C2794 cp_0/vbias gnd 2.41fF
C2795 cp_0/out gnd 5.26fF
C2796 cp_0/upbar gnd 1.50fF
C2797 cp_0/a_7110_n2840# gnd 0.17fF **FLOATING
C2798 cp_0/a_3060_n2840# gnd 1.71fF **FLOATING
C2799 cp_0/a_7110_0# gnd 0.17fF **FLOATING
C2800 cp_0/a_6370_0# gnd 0.40fF **FLOATING
C2801 cp_0/a_3060_0# gnd 1.65fF **FLOATING
C2802 cp_0/a_1710_0# gnd 5.76fF **FLOATING
C2803 cp_0/a_1710_n2840# gnd 4.89fF **FLOATING
C2804 cp_0/a_10_n50# gnd 2.96fF **FLOATING
C2805 pd_1/and_pd_0/Z1 gnd 0.39fF
C2806 pd_1/and_pd_0/Out1 gnd 2.22fF
C2807 pd_1/tspc_r_1/z5 gnd 1.10fF
C2808 pd_1/tspc_r_1/Z4 gnd 1.07fF
C2809 pd_1/tspc_r_1/Qbar gnd 0.88fF
C2810 pd_1/tspc_r_1/Z2 gnd 1.22fF
C2811 pd_1/tspc_r_1/Z1 gnd 0.67fF
C2812 pd_1/UP gnd 2.21fF
C2813 pd_1/tspc_r_1/Qbar1 gnd 1.34fF
C2814 pd_1/tspc_r_1/Z3 gnd 2.12fF
C2815 pd_1/REF gnd 1.80fF
C2816 pd_1/tspc_r_0/z5 gnd 1.10fF
C2817 pd_1/tspc_r_0/Z4 gnd 1.07fF
C2818 pd_1/R gnd 3.05fF
C2819 pd_1/tspc_r_0/Qbar gnd 0.79fF
C2820 pd_1/tspc_r_0/Z2 gnd 1.22fF
C2821 pd_1/tspc_r_0/Z1 gnd 0.67fF
C2822 pd_1/DOWN gnd 3.08fF
C2823 pd_1/tspc_r_0/Qbar1 gnd 1.34fF
C2824 pd_1/tspc_r_0/Z3 gnd 2.12fF
C2825 pd_1/DIV gnd 1.82fF
C2826 pd_0/and_pd_0/Z1 gnd 0.39fF
C2827 pd_0/and_pd_0/Out1 gnd 2.22fF
C2828 pd_0/tspc_r_1/z5 gnd 1.10fF
C2829 pd_0/tspc_r_1/Z4 gnd 1.07fF
C2830 pd_0/tspc_r_1/Qbar gnd 0.88fF
C2831 pd_0/tspc_r_1/Z2 gnd 1.22fF
C2832 pd_0/tspc_r_1/Z1 gnd 0.67fF
C2833 pd_0/UP gnd 2.21fF
C2834 pd_0/tspc_r_1/Qbar1 gnd 1.34fF
C2835 pd_0/tspc_r_1/Z3 gnd 2.12fF
C2836 pd_0/REF gnd 1.80fF
C2837 pd_0/tspc_r_0/z5 gnd 1.10fF
C2838 pd_0/tspc_r_0/Z4 gnd 1.07fF
C2839 pd_0/R gnd 3.05fF
C2840 pd_0/tspc_r_0/Qbar gnd 0.79fF
C2841 pd_0/tspc_r_0/Z2 gnd 1.22fF
C2842 pd_0/tspc_r_0/Z1 gnd 0.67fF
C2843 pd_0/DOWN gnd 3.08fF
C2844 pd_0/tspc_r_0/Qbar1 gnd 1.34fF
C2845 pd_0/tspc_r_0/Z3 gnd 2.12fF
C2846 pd_0/DIV gnd 1.82fF
.ends
