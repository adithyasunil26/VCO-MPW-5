* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C1 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z2 0.30fF
C2 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C3 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C4 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C5 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C6 io_clamp_low[1] io_analog[5] 0.53fF
C7 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C8 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C9 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C10 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C11 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C12 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C13 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C14 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C15 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C16 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C17 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C18 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C19 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C20 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C21 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z1 0.03fF
C22 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C23 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C24 pll_full_0/pd_0/R pll_full_0/pd_0/DOWN 0.36fF
C25 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/nor_0/A 0.03fF
C26 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar 0.21fF
C27 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C28 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C29 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z3 0.16fF
C30 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C31 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C32 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C33 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C34 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C35 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C36 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/tspc_r_1/Qbar 0.05fF
C37 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z2 0.30fF
C38 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C39 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C40 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C41 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C42 divider_1/tspc_1/Q divider_1/tspc_0/a_630_n680# 0.01fF
C43 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C44 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C45 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_2/Q 0.01fF
C46 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/a_630_n680# 0.35fF
C47 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C48 pll_full_1/cp_0/down pll_full_1/cp_0/a_1710_0# 0.32fF
C49 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C50 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/tspc_r_1/Qbar 0.02fF
C51 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z3 0.05fF
C52 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C53 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C54 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z3 0.45fF
C55 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C56 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z3 0.25fF
C57 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C58 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C59 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C60 divider_1/nor_0/B divider_1/tspc_1/Z3 0.38fF
C61 divider_1/tspc_0/a_630_n680# divider_1/tspc_0/Z3 0.05fF
C62 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C63 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C64 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C65 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C66 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C67 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C68 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z3 0.16fF
C69 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C70 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C71 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DOWN 0.03fF
C72 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C73 divider_0/tspc_0/Z2 divider_0/nor_1/B 0.40fF
C74 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C75 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C76 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C77 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C78 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C79 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C80 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Qbar1 0.38fF
C81 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C82 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C83 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C84 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C85 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C86 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C87 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C88 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C89 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_2/Q 0.01fF
C90 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/a_630_n680# 0.35fF
C91 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C92 divider_1/prescaler_0/Out divider_1/prescaler_0/m1_2700_2190# 0.11fF
C93 divider_1/nor_1/B divider_1/tspc_0/Z1 0.03fF
C94 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C95 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C96 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C97 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C98 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/R 0.29fF
C99 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Q 0.51fF
C100 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/Z4 0.36fF
C101 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C102 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z1 0.71fF
C103 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DOWN 0.03fF
C104 cp_0/a_1710_n2840# cp_0/upbar 0.29fF
C105 pd_1/R pd_1/REF 0.61fF
C106 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C107 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C108 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z1 0.06fF
C109 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C110 divider_1/tspc_0/Z2 divider_1/tspc_0/Z1 1.07fF
C111 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C112 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C113 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C114 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C115 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C116 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C117 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C118 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C119 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C120 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C121 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C122 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C123 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C124 cp_0/upbar cp_0/down 0.02fF
C125 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C126 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C127 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C128 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C129 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C130 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C131 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C132 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C133 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C134 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C135 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C136 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C137 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C138 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C139 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C140 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Q 0.51fF
C141 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/Z4 0.36fF
C142 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C143 divider_1/nor_1/B divider_1/tspc_1/Q 0.22fF
C144 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C145 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C146 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C147 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C148 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C149 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C150 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C151 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/DIV 0.19fF
C152 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C153 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z3 0.16fF
C154 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C155 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C156 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C157 divider_1/tspc_0/Z4 divider_1/nor_0/B 0.02fF
C158 divider_1/tspc_0/Z2 divider_1/tspc_1/Q 0.14fF
C159 divider_1/nor_1/B divider_1/tspc_0/Z3 0.38fF
C160 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C161 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C162 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C163 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C164 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C165 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C166 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C167 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C168 cp_0/a_1710_n2840# cp_0/out 0.61fF
C169 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C170 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C171 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C172 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C173 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C174 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/nor_0/A 0.01fF
C175 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z4 0.12fF
C176 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C177 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C178 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/REF 0.17fF
C179 divider_1/tspc_0/Z2 divider_1/tspc_0/Z3 0.16fF
C180 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C181 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C182 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C183 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C184 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C185 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C186 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C187 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z3 0.05fF
C188 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C189 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C190 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C191 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C192 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C193 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C194 divider_0/nor_0/B divider_0/tspc_2/Q 0.22fF
C195 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C196 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C197 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C198 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C199 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C200 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C201 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C202 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C203 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C204 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C205 divider_1/tspc_2/Q divider_1/tspc_2/a_630_n680# 0.04fF
C206 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C207 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C208 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C209 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C210 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C211 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C212 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C213 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/a_630_n680# 0.01fF
C214 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C215 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C216 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C217 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C218 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C219 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C220 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C221 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C222 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C223 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C224 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C225 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C226 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/UP 0.11fF
C227 pll_full_0/pd_0/REF pll_full_0/pd_0/DOWN 1.48fF
C228 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C229 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C230 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C231 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C232 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Qbar1 0.38fF
C233 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C234 divider_0/tspc_0/Z2 divider_0/tspc_0/a_630_n680# 0.01fF
C235 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z3 0.05fF
C236 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C237 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C238 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C239 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C240 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C241 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C242 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/Z3 0.05fF
C243 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C244 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C245 pll_full_1/pd_0/UP pll_full_1/pd_0/R 0.46fF
C246 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C247 pd_0/DIV pd_0/R 0.51fF
C248 io_clamp_high[0] io_analog[4] 0.53fF
C249 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_0/B 0.18fF
C250 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/DOWN 0.21fF
C251 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C252 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C253 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C254 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C255 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C256 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C257 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C258 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C259 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C260 pd_1/DIV pd_1/tspc_r_0/Qbar1 0.12fF
C261 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C262 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C263 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C264 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C265 divider_0/nor_0/B divider_0/tspc_1/Z3 0.38fF
C266 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C267 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C268 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C269 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C270 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C271 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C272 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C273 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C274 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C275 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C276 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C277 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C278 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C279 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/R 0.33fF
C280 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/Z3 0.05fF
C281 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C282 pll_full_1/divbuf_0/IN pll_full_1/divider_0/nor_1/B 0.27fF
C283 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z1 0.00fF
C284 divider_1/Out divider_1/tspc_0/a_630_n680# 0.04fF
C285 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C286 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z4 0.02fF
C287 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C288 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C289 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C290 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C291 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C292 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C293 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/R 0.02fF
C294 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C295 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C296 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C297 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C298 divider_0/tspc_0/Z2 divider_0/tspc_1/Q 0.14fF
C299 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C300 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C301 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C302 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C303 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C304 divider_1/tspc_2/Q divider_1/tspc_1/Z2 0.14fF
C305 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C306 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C307 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C308 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C309 pll_full_1/pd_0/R pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C310 pd_0/DOWN pd_0/UP 0.46fF
C311 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C312 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C313 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C314 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C315 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C316 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C317 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C318 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C319 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C320 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C321 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C322 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C323 divider_1/tspc_2/Q divider_1/nor_0/A 0.55fF
C324 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C325 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C326 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C327 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C328 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT 0.00fF
C329 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DIV 0.12fF
C330 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_0/Z4 0.02fF
C331 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C332 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C333 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z2 0.36fF
C334 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/Z3 0.05fF
C335 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C336 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C337 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C338 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C339 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C340 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z2 0.01fF
C341 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C342 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C343 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C344 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C345 divider_1/mc2 divider_1/nor_0/A 0.04fF
C346 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C347 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C348 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C349 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/nor_1/B 0.03fF
C350 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C351 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C352 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C353 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/Z2 0.14fF
C354 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C355 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C356 pll_full_1/pd_0/DOWN pll_full_1/pd_0/UP 4.58fF
C357 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C358 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C359 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C360 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C361 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C362 pd_1/DIV pd_1/tspc_r_0/Z1 0.17fF
C363 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C364 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C365 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C366 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C367 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C368 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C369 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C370 divider_0/mc2 divider_0/nor_1/B 0.15fF
C371 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C372 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C373 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C374 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C375 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C376 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C377 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C378 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C379 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C380 divider_1/nor_1/B divider_1/Out 0.22fF
C381 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/nor_1/B 0.03fF
C382 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_0/a_630_n680# 0.04fF
C383 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C384 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C385 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/UP 0.21fF
C386 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C387 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C388 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C389 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/UP 0.03fF
C390 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z4 0.02fF
C391 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C392 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divbuf_0/IN 0.04fF
C393 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C394 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/IN 0.00fF
C395 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C396 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C397 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C398 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C399 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C400 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C401 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C402 divider_1/mc2 divider_1/and_0/B 0.20fF
C403 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C404 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C405 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/R 0.33fF
C406 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C407 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C408 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/IN 5.26fF
C409 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C410 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C411 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C412 cp_0/a_10_n50# cp_0/vbias 0.19fF
C413 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C414 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C415 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C416 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C417 divider_0/tspc_0/Z2 divider_0/tspc_0/Z3 0.16fF
C418 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C419 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C420 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C421 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C422 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C423 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C424 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C425 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT5 0.02fF
C426 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C427 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C428 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C429 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Z1 0.07fF
C430 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z3 0.05fF
C431 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C432 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C433 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C434 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C435 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C436 pd_0/R pd_0/REF 0.61fF
C437 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C438 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C439 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divbuf_0/IN 0.04fF
C440 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C441 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C442 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C443 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C444 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_0/B 0.20fF
C445 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z1 0.09fF
C446 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C447 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C448 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C449 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C450 divider_1/nor_1/B divider_1/tspc_0/a_630_n680# 0.35fF
C451 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C452 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C453 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C454 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C455 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C456 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C457 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C458 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z4 0.14fF
C459 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C460 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C461 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT4 5.16fF
C462 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C463 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C464 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/IN 0.13fF
C465 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C466 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C467 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C468 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C469 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C470 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C471 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C472 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C473 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C474 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C475 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C476 pll_full_1/pd_0/DOWN pll_full_1/cp_0/a_1710_0# 0.04fF
C477 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C478 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C479 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C480 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C481 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C482 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C483 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_0/B 0.20fF
C484 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/R 0.03fF
C485 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C486 divider_0/tspc_0/Z2 divider_0/tspc_0/Z4 0.36fF
C487 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C488 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C489 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C490 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C491 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C492 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/DIV 0.65fF
C493 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C494 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C495 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C496 divider_0/mc2 divider_0/nor_0/A 0.04fF
C497 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C498 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C499 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z4 0.20fF
C500 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C501 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C502 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C503 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C504 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C505 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C506 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C507 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C508 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C509 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C510 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C511 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C512 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Out1 0.12fF
C513 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C514 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C515 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C516 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C517 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/OUT2 0.06fF
C518 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT3 0.01fF
C519 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C520 io_clamp_low[2] io_analog[6] 0.53fF
C521 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z3 0.05fF
C522 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT 0.26fF
C523 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT5 20.26fF
C524 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z2 0.25fF
C525 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C526 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C527 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C528 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z4 0.12fF
C529 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C530 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C531 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C532 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C533 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z2 0.71fF
C534 pd_1/DIV pd_1/R 0.51fF
C535 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C536 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C537 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C538 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z2 0.19fF
C539 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C540 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C541 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C542 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C543 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C544 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_1/Q 0.01fF
C545 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C546 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/a_492_n240# 0.00fF
C547 divider_1/nor_1/B divider_1/tspc_0/Z2 0.40fF
C548 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C549 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C550 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C551 divider_0/mc2 divider_0/and_0/B 0.20fF
C552 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C553 divider_1/tspc_1/Q divider_1/nor_0/B 0.51fF
C554 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C555 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C556 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C557 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C558 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT5 0.01fF
C559 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C560 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C561 cp_0/a_10_n50# cp_0/a_1710_0# 0.04fF
C562 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C563 divider_1/nor_1/B divider_1/mc2 0.15fF
C564 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C565 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_0/A 0.15fF
C566 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C567 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C568 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C569 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C570 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/REF 0.04fF
C571 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT3 0.26fF
C572 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Z1 0.06fF
C573 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C574 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C575 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C576 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C577 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C578 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C579 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C580 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C581 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_1/Q 0.01fF
C582 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C583 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C584 divider_0/tspc_1/Q divider_0/tspc_0/Z3 0.45fF
C585 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C586 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C587 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C588 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C589 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C590 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C591 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C592 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C593 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C594 vdda1 vssa1 78.07fF
C595 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C596 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C597 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C598 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C599 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C600 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C601 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C602 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C603 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C604 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C605 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/Z3 0.20fF
C606 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C607 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C608 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C609 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C610 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C611 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/OUT4 1.11fF
C612 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C613 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C614 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C615 pd_1/UP pd_1/tspc_r_1/Qbar 0.21fF
C616 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C617 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C618 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C619 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z4 0.04fF
C620 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C621 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C622 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C623 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C624 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C625 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C626 divider_1/nor_1/B divider_1/nor_1/Z1 0.06fF
C627 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C628 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C629 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C630 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z3 0.06fF
C631 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C632 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C633 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C634 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C635 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C636 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C637 divider_1/tspc_0/Z4 divider_1/tspc_0/Z1 0.00fF
C638 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C639 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C640 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C641 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C642 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/Q 0.22fF
C643 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C644 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C645 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C646 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/UP 0.33fF
C647 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C648 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C649 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT5 20.26fF
C650 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C651 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C652 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C653 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/R 0.29fF
C654 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z2 0.11fF
C655 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C656 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z2 0.01fF
C657 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C658 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C659 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/DIV 0.12fF
C660 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C661 divider_1/nor_0/B divider_1/tspc_1/Z2 0.30fF
C662 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C663 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C664 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C665 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C666 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C667 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C668 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Qbar1 0.38fF
C669 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C670 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C671 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C672 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C673 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C674 pd_1/UP pd_1/and_pd_0/Z1 0.06fF
C675 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C676 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z3 0.06fF
C677 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C678 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C679 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C680 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C681 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C682 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C683 divider_0/tspc_0/Z1 divider_0/nor_1/B 0.03fF
C684 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C685 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C686 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C687 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C688 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_1/Z4 0.04fF
C689 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C690 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C691 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C692 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C693 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C694 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C695 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C696 pd_0/UP pd_0/tspc_r_1/Qbar 0.21fF
C697 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C698 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C699 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/Q 0.22fF
C700 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C701 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C702 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C703 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C704 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C705 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C706 divider_1/tspc_0/Z4 divider_1/tspc_1/Q 0.15fF
C707 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C708 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C709 divider_1/and_0/OUT divider_1/clk 0.04fF
C710 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z4 0.00fF
C711 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C712 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C713 pd_1/DOWN pd_1/UP 0.46fF
C714 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Qbar1 0.20fF
C715 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z1 1.07fF
C716 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C717 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.00fF
C718 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C719 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C720 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C721 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C722 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C723 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C724 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C725 divider_1/tspc_0/Z4 divider_1/tspc_0/Z3 0.65fF
C726 divider_1/nor_0/B divider_1/tspc_1/Z1 0.03fF
C727 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/OUT2 0.42fF
C728 io_clamp_low[2] io_clamp_high[2] 0.53fF
C729 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/and_pd_0/Z1 0.18fF
C730 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C731 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C732 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z3 0.38fF
C733 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C734 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C735 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C736 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT2 0.42fF
C737 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C738 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C739 io_clamp_high[1] io_analog[5] 0.53fF
C740 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C741 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C742 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C743 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT3 5.16fF
C744 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C745 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C746 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C747 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C748 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C749 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C750 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z4 0.00fF
C751 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C752 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C753 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C754 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C755 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C756 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C757 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C758 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C759 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C760 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/R 0.27fF
C761 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C762 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C763 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C764 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C765 pd_0/UP pd_0/and_pd_0/Z1 0.06fF
C766 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C767 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z3 0.38fF
C768 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C769 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C770 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C771 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C772 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/tspc_r_1/Qbar 0.01fF
C773 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C774 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C775 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C776 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C777 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C778 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C779 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C780 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C781 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C782 divider_0/tspc_0/Z2 divider_0/nor_0/B 0.20fF
C783 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C784 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C785 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/Z3 0.38fF
C786 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C787 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C788 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C789 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C790 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C791 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Qbar 0.03fF
C792 divider_1/and_0/A divider_1/and_0/B 0.18fF
C793 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z2 0.01fF
C794 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C795 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C796 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C797 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C798 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C799 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C800 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C801 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C802 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C803 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C804 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C805 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C806 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C807 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C808 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C809 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Qbar 0.01fF
C810 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C811 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C812 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C813 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C814 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C815 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C816 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C817 pll_full_1/cp_0/down pll_full_1/cp_0/upbar 0.02fF
C818 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C819 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C820 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C821 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C822 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z2 0.01fF
C823 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C824 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C825 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C826 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C827 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C828 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C829 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C830 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C831 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C832 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C833 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C834 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C835 io_clamp_low[0] io_analog[4] 0.53fF
C836 pd_1/UP pd_1/tspc_r_1/z5 0.03fF
C837 divider_0/nor_0/B divider_0/tspc_1/Z1 0.03fF
C838 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C839 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C840 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT3 0.01fF
C841 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C842 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C843 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C844 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C845 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C846 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C847 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C848 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C849 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C850 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C851 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C852 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C853 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C854 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C855 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C856 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C857 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C858 divider_0/nor_0/B divider_0/tspc_1/Z2 0.30fF
C859 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/DIV 0.19fF
C860 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C861 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C862 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C863 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C864 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C865 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C866 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C867 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C868 pll_full_0/pd_0/REF pll_full_0/pd_0/R 0.61fF
C869 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C870 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C871 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C872 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C873 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C874 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/Qbar 0.01fF
C875 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C876 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C877 divider_1/mc2 divider_1/and_0/out1 0.06fF
C878 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C879 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C880 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C881 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C882 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C883 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C884 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C885 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C886 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C887 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C888 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C889 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C890 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C891 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C892 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C893 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C894 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C895 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C896 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C897 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C898 divider_0/tspc_0/Z1 divider_0/tspc_1/Q 0.01fF
C899 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C900 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C901 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/REF 0.19fF
C902 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/Qbar 0.02fF
C903 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_1/Qbar1 0.20fF
C904 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C905 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C906 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C907 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C908 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C909 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C910 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C911 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C912 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C913 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.01fF
C914 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C915 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C916 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C917 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C918 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C919 divider_0/tspc_1/Z1 divider_0/tspc_2/Q 0.01fF
C920 divider_0/nor_0/B divider_0/tspc_1/a_630_n680# 0.35fF
C921 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C922 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/R 0.01fF
C923 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C924 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C925 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z3 0.65fF
C926 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C927 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C928 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C929 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C930 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C931 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C932 pd_0/UP pd_0/tspc_r_1/z5 0.03fF
C933 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Qbar1 0.20fF
C934 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT5 0.01fF
C935 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C936 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C937 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C938 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C939 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_1/z5 0.02fF
C940 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C941 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_630_n680# 0.05fF
C942 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C943 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C944 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C945 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C946 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C947 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C948 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C949 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C950 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C951 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C952 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C953 pd_1/R pd_1/UP 0.45fF
C954 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/DOWN 0.12fF
C955 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/UP 0.03fF
C956 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C957 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_1/B 0.22fF
C958 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C959 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C960 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C961 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C962 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C963 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C964 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C965 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C966 io_clamp_low[1] io_clamp_high[1] 0.53fF
C967 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C968 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C969 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C970 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C971 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C972 cp_0/a_1710_0# cp_0/out 0.84fF
C973 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C974 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/DOWN 0.07fF
C975 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/DIV 0.02fF
C976 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C977 divider_0/nor_0/B divider_0/tspc_1/Q 0.51fF
C978 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C979 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C980 divider_1/mc2 divider_1/nor_0/B 0.06fF
C981 divider_0/and_0/OUT divider_0/clk 0.04fF
C982 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C983 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C984 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C985 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C986 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C987 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C988 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C989 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C990 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C991 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C992 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C993 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C994 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C995 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/tspc_r_0/Z3 0.25fF
C996 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C997 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C998 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z3 0.05fF
C999 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C1000 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C1001 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C1002 pd_1/DOWN pd_1/tspc_r_0/Qbar1 0.11fF
C1003 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1004 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1005 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C1006 divider_1/tspc_0/Z4 divider_1/tspc_0/a_630_n680# 0.12fF
C1007 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C1008 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C1009 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C1010 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1011 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1012 divider_1/mc2 divider_1/and_0/A 0.16fF
C1013 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C1014 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C1015 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1016 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C1017 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C1018 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C1019 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C1020 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C1021 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1022 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C1023 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C1024 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C1025 divider_0/tspc_0/Z1 divider_0/tspc_0/Z3 0.06fF
C1026 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1027 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C1028 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1029 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C1030 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C1031 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C1032 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1033 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1034 divider_1/tspc_1/a_630_n680# divider_1/tspc_1/Z2 0.01fF
C1035 divider_1/tspc_2/Q divider_1/tspc_1/Z3 0.45fF
C1036 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C1037 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1038 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1039 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1040 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C1041 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C1042 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C1043 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C1044 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C1045 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C1046 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z3 0.05fF
C1047 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/DOWN 0.11fF
C1048 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1049 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C1050 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C1051 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/tspc_r_1/Z4 0.14fF
C1052 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C1053 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C1054 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1055 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C1056 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C1057 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C1058 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C1059 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C1060 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/Z3 0.65fF
C1061 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1062 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z3 0.05fF
C1063 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C1064 pll_full_1/pd_0/DOWN pll_full_1/pd_0/REF 1.48fF
C1065 divider_1/tspc_1/Q divider_1/tspc_0/Z1 0.01fF
C1066 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1067 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1068 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1069 pll_full_1/pd_0/DIV pll_full_1/pd_0/R 0.51fF
C1070 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C1071 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C1072 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z3 0.45fF
C1073 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/nor_1/B 0.40fF
C1074 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1075 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C1076 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C1077 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C1078 cp_0/a_1710_n2840# cp_0/a_1710_0# 0.83fF
C1079 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C1080 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C1081 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C1082 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C1083 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1084 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/DIV 0.04fF
C1085 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1086 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_1/Z3 0.11fF
C1087 divider_1/tspc_0/Z1 divider_1/tspc_0/Z3 0.06fF
C1088 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar 0.21fF
C1089 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1090 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1091 pd_1/DIV pd_1/tspc_r_0/Z2 0.19fF
C1092 pd_0/DOWN pd_0/R 0.36fF
C1093 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C1094 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C1095 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C1096 pll_full_1/divbuf_0/OUT2 pll_full_1/divbuf_0/a_492_n240# 0.42fF
C1097 cp_0/a_1710_0# cp_0/down 0.32fF
C1098 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C1099 divider_0/tspc_0/Z1 divider_0/tspc_0/Z4 0.00fF
C1100 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1101 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/DIV 0.17fF
C1102 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1103 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C1104 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C1105 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1106 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/REF 0.65fF
C1107 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C1108 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C1109 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1110 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C1111 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1112 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1113 divider_1/nor_1/B divider_1/tspc_0/Z4 0.22fF
C1114 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C1115 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z3 0.45fF
C1116 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/nor_1/B 0.40fF
C1117 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1118 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C1119 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/a_630_n680# 0.12fF
C1120 divider_0/tspc_1/Q divider_0/tspc_1/Z3 0.05fF
C1121 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1122 divider_0/Out divider_0/nor_1/B 0.22fF
C1123 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C1124 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C1125 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1126 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C1127 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C1128 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C1129 divider_1/tspc_0/Z4 divider_1/tspc_0/Z2 0.36fF
C1130 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C1131 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C1132 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C1133 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1134 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C1135 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_1/pd_0/R 0.21fF
C1136 divider_1/tspc_1/Q divider_1/tspc_0/Z3 0.45fF
C1137 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C1138 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C1139 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1140 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C1141 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT2 0.02fF
C1142 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C1143 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C1144 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1145 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT 0.06fF
C1146 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT5 0.01fF
C1147 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1148 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C1149 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1150 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C1151 divider_1/tspc_2/Q divider_1/tspc_1/Z4 0.15fF
C1152 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C1153 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C1154 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Z1 0.02fF
C1155 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1156 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C1157 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1158 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z2 0.71fF
C1159 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z1 0.08fF
C1160 divider_0/nor_0/B divider_0/tspc_0/Z4 0.02fF
C1161 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1162 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/DOWN 0.02fF
C1163 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C1164 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1165 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1166 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1167 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1168 divider_1/tspc_2/Q divider_1/tspc_2/Z3 0.05fF
C1169 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/a_492_n240# 0.01fF
C1170 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C1171 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C1172 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C1173 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C1174 divider_0/mc2 divider_0/and_0/A 0.16fF
C1175 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1176 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1177 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C1178 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C1179 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C1180 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C1181 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C1182 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C1183 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C1184 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C1185 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C1186 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1187 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C1188 pll_full_1/pd_0/tspc_r_0/z5 pll_full_1/pd_0/tspc_r_0/Z3 0.11fF
C1189 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1190 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1191 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1192 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1193 io_clamp_low[0] io_clamp_high[0] 0.53fF
C1194 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C1195 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C1196 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C1197 pd_1/UP pd_1/and_pd_0/Out1 0.33fF
C1198 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1199 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z3 0.09fF
C1200 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1201 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_0/a_630_n680# 0.01fF
C1202 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/UP 0.03fF
C1203 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C1204 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/and_pd_0/Out1 0.18fF
C1205 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C1206 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C1207 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C1208 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C1209 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C1210 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C1211 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C1212 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1213 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z4 0.20fF
C1214 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C1215 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C1216 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C1217 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C1218 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1219 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C1220 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1221 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C1222 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C1223 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C1224 pll_full_1/pd_0/and_pd_0/Out1 pll_full_1/pd_0/tspc_r_1/Qbar 0.05fF
C1225 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C1226 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C1227 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/OUT3 0.26fF
C1228 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT4 20.26fF
C1229 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1230 io_clamp_high[2] io_analog[6] 0.53fF
C1231 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C1232 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_0/a_630_n680# 0.01fF
C1233 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C1234 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C1235 divider_0/tspc_0/a_630_n680# divider_0/Out 0.04fF
C1236 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C1237 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C1238 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1239 pll_full_0/divbuf_1/OUT4 pll_full_0/divbuf_1/OUT 1.11fF
C1240 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1241 pd_0/R pd_0/UP 0.45fF
C1242 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C1243 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1244 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/R 0.21fF
C1245 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1246 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1247 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1248 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1249 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C1250 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/divider_0/tspc_1/Q 0.14fF
C1251 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C1252 pd_1/DOWN pd_1/R 0.36fF
C1253 pd_0/UP pd_0/and_pd_0/Out1 0.33fF
C1254 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C1255 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/B 0.47fF
C1256 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C1257 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C1258 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C1259 divider_1/nor_1/B divider_1/tspc_1/a_630_n680# 0.00fF
C1260 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C1261 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1262 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1263 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Z3 0.03fF
C1264 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1265 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_1/pd_0/R 0.30fF
C1266 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C1267 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1268 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C1269 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1270 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1271 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1272 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z3 0.33fF
C1273 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C1274 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1275 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C1276 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C1277 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C1278 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Z3 0.38fF
C1279 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C1280 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C1281 pll_full_1/divider_0/tspc_0/Z2 pll_full_1/divider_0/tspc_1/Q 0.14fF
C1282 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C1283 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1284 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1285 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C1286 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C1287 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C1288 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/R 0.30fF
C1289 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1290 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C1291 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1292 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C1293 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1294 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C1295 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C1296 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C1297 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1298 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z3 0.09fF
C1299 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/Z4 0.20fF
C1300 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z1 0.03fF
C1301 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C1302 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C1303 pd_1/tspc_r_0/z5 pd_1/tspc_r_0/Z3 0.11fF
C1304 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1305 pll_full_0/cp_0/a_1710_0# pll_full_0/pd_0/DOWN 0.04fF
C1306 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/tspc_r_0/z5 0.02fF
C1307 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1308 divider_1/Out divider_1/tspc_0/Z3 0.05fF
C1309 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
Xpd_0 VDD gnd pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 VDD gnd pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdd gnd cp_0/out cp_0/down cp_0/upbar cp
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivider_1 gnd vdd divider_1/Out divider_1/clk divider_1/mc2 divider
Xpll_full_1 vdd pll_full
Xpll_full_0 vdd pll_full
C1310 io_analog[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 25.05fF
C1311 io_analog[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 25.05fF
C1312 io_analog[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 25.05fF
C1313 io_in_3v3[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1314 io_oeb[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1315 io_in[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1316 io_out[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1317 io_out[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1318 io_in[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1319 io_oeb[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1320 io_in_3v3[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1321 io_in_3v3[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1322 io_oeb[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1323 io_in[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1324 io_out[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1325 io_out[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1326 io_in[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1327 io_oeb[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1328 io_in_3v3[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1329 io_in_3v3[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1330 io_oeb[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1331 io_in[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1332 io_out[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1333 io_out[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1334 io_in[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1335 io_oeb[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1336 io_in_3v3[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1337 io_in_3v3[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1338 gpio_noesd[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1339 io_in[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1340 gpio_analog[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1341 io_out[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1342 io_oeb[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1343 io_in_3v3[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1344 io_in[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1345 io_out[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1346 io_oeb[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1347 io_oeb[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1348 io_out[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1349 io_in[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1350 io_in_3v3[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1351 gpio_noesd[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1352 gpio_analog[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1353 io_in_3v3[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1354 io_in[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1355 io_out[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1356 io_oeb[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1357 io_oeb[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1358 io_out[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1359 io_in[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1360 io_in_3v3[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1361 gpio_noesd[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1362 gpio_analog[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1363 io_in_3v3[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1364 io_in[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1365 io_out[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1366 io_oeb[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1367 io_oeb[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1368 io_out[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1369 io_in[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1370 io_in_3v3[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1371 gpio_noesd[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1372 gpio_analog[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1373 vssa1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1468.81fF
C1374 vssd2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 13.04fF
C1375 vssd1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 13.04fF
C1376 vdda2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 13.04fF
C1377 vdda1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1116.08fF
C1378 io_oeb[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1379 io_out[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1380 io_in[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1381 io_in_3v3[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1382 gpio_noesd[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1383 gpio_analog[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1384 gpio_analog[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1385 gpio_noesd[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1386 io_in_3v3[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1387 io_in[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1388 io_out[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1389 io_oeb[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1390 io_oeb[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1391 io_out[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1392 io_in[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1393 io_in_3v3[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1394 gpio_noesd[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1395 gpio_analog[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1396 gpio_analog[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1397 gpio_noesd[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1398 io_in_3v3[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1399 io_in[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1400 io_out[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1401 io_oeb[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1402 io_oeb[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1403 io_out[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1404 io_in[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1405 io_in_3v3[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1406 gpio_noesd[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1407 gpio_analog[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1408 gpio_analog[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1409 gpio_noesd[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1410 io_in_3v3[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1411 io_in[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1412 io_out[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1413 io_oeb[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1414 io_oeb[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1415 io_out[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1416 io_in[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1417 io_in_3v3[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1418 gpio_noesd[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1419 gpio_analog[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1420 gpio_analog[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1421 gpio_noesd[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1422 io_in_3v3[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1423 io_in[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1424 io_out[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1425 io_oeb[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1426 io_oeb[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1427 io_out[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1428 io_in[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1429 io_in_3v3[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1430 gpio_noesd[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1431 gpio_analog[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1432 gpio_analog[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1433 gpio_noesd[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1434 io_in_3v3[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1435 io_in[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1436 io_out[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1437 io_oeb[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1438 io_oeb[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1439 io_out[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1440 io_in[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1441 io_in_3v3[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1442 gpio_noesd[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1443 gpio_analog[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1444 gpio_analog[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1445 gpio_noesd[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1446 io_in_3v3[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1447 io_in[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1448 io_out[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1449 io_oeb[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1450 io_oeb[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1451 io_out[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1452 io_in[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1453 io_in_3v3[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1454 gpio_noesd[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1455 gpio_analog[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1456 vssa2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 13.04fF
C1457 gpio_analog[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1458 gpio_noesd[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1459 io_in_3v3[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1460 io_in[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1461 io_out[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1462 io_oeb[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.61fF
C1463 vccd1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 13.04fF
C1464 vccd2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 13.04fF
C1465 io_analog[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1466 io_analog[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1467 io_analog[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1468 io_analog[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1469 io_analog[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1470 io_clamp_high[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.58fF
C1471 io_clamp_low[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.58fF
C1472 io_clamp_high[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.58fF
C1473 io_clamp_low[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.58fF
C1474 io_clamp_high[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.58fF
C1475 io_clamp_low[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.58fF
C1476 io_analog[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1477 io_analog[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1478 io_analog[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.83fF
C1479 user_irq[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1480 user_irq[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1481 user_irq[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1482 user_clock2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1483 la_oenb[127] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1484 la_data_out[127] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1485 la_data_in[127] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1486 la_oenb[126] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1487 la_data_out[126] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1488 la_data_in[126] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1489 la_oenb[125] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1490 la_data_out[125] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1491 la_data_in[125] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1492 la_oenb[124] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1493 la_data_out[124] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1494 la_data_in[124] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1495 la_oenb[123] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1496 la_data_out[123] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1497 la_data_in[123] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1498 la_oenb[122] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1499 la_data_out[122] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1500 la_data_in[122] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1501 la_oenb[121] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1502 la_data_out[121] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1503 la_data_in[121] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1504 la_oenb[120] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1505 la_data_out[120] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1506 la_data_in[120] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1507 la_oenb[119] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1508 la_data_out[119] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1509 la_data_in[119] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1510 la_oenb[118] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1511 la_data_out[118] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1512 la_data_in[118] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1513 la_oenb[117] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1514 la_data_out[117] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1515 la_data_in[117] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1516 la_oenb[116] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1517 la_data_out[116] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1518 la_data_in[116] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1519 la_oenb[115] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1520 la_data_out[115] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1521 la_data_in[115] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1522 la_oenb[114] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1523 la_data_out[114] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1524 la_data_in[114] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1525 la_oenb[113] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1526 la_data_out[113] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1527 la_data_in[113] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1528 la_oenb[112] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1529 la_data_out[112] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1530 la_data_in[112] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1531 la_oenb[111] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1532 la_data_out[111] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1533 la_data_in[111] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1534 la_oenb[110] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1535 la_data_out[110] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1536 la_data_in[110] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1537 la_oenb[109] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1538 la_data_out[109] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1539 la_data_in[109] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1540 la_oenb[108] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1541 la_data_out[108] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1542 la_data_in[108] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1543 la_oenb[107] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1544 la_data_out[107] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1545 la_data_in[107] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1546 la_oenb[106] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1547 la_data_out[106] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1548 la_data_in[106] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1549 la_oenb[105] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1550 la_data_out[105] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1551 la_data_in[105] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1552 la_oenb[104] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1553 la_data_out[104] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1554 la_data_in[104] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1555 la_oenb[103] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1556 la_data_out[103] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1557 la_data_in[103] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1558 la_oenb[102] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1559 la_data_out[102] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1560 la_data_in[102] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1561 la_oenb[101] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1562 la_data_out[101] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1563 la_data_in[101] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1564 la_oenb[100] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1565 la_data_out[100] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1566 la_data_in[100] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1567 la_oenb[99] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1568 la_data_out[99] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1569 la_data_in[99] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1570 la_oenb[98] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1571 la_data_out[98] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1572 la_data_in[98] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1573 la_oenb[97] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1574 la_data_out[97] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1575 la_data_in[97] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1576 la_oenb[96] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1577 la_data_out[96] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1578 la_data_in[96] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1579 la_oenb[95] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1580 la_data_out[95] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1581 la_data_in[95] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1582 la_oenb[94] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1583 la_data_out[94] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1584 la_data_in[94] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1585 la_oenb[93] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1586 la_data_out[93] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1587 la_data_in[93] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1588 la_oenb[92] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1589 la_data_out[92] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1590 la_data_in[92] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1591 la_oenb[91] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1592 la_data_out[91] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1593 la_data_in[91] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1594 la_oenb[90] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1595 la_data_out[90] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1596 la_data_in[90] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1597 la_oenb[89] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1598 la_data_out[89] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1599 la_data_in[89] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1600 la_oenb[88] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1601 la_data_out[88] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1602 la_data_in[88] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1603 la_oenb[87] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1604 la_data_out[87] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1605 la_data_in[87] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1606 la_oenb[86] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1607 la_data_out[86] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1608 la_data_in[86] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1609 la_oenb[85] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1610 la_data_out[85] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1611 la_data_in[85] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1612 la_oenb[84] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1613 la_data_out[84] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1614 la_data_in[84] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1615 la_oenb[83] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1616 la_data_out[83] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1617 la_data_in[83] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1618 la_oenb[82] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1619 la_data_out[82] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1620 la_data_in[82] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1621 la_oenb[81] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1622 la_data_out[81] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1623 la_data_in[81] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1624 la_oenb[80] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1625 la_data_out[80] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1626 la_data_in[80] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1627 la_oenb[79] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1628 la_data_out[79] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1629 la_data_in[79] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1630 la_oenb[78] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1631 la_data_out[78] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1632 la_data_in[78] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1633 la_oenb[77] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1634 la_data_out[77] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1635 la_data_in[77] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1636 la_oenb[76] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1637 la_data_out[76] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1638 la_data_in[76] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1639 la_oenb[75] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1640 la_data_out[75] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1641 la_data_in[75] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1642 la_oenb[74] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1643 la_data_out[74] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1644 la_data_in[74] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1645 la_oenb[73] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1646 la_data_out[73] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1647 la_data_in[73] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1648 la_oenb[72] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1649 la_data_out[72] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1650 la_data_in[72] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1651 la_oenb[71] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1652 la_data_out[71] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1653 la_data_in[71] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1654 la_oenb[70] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1655 la_data_out[70] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1656 la_data_in[70] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1657 la_oenb[69] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1658 la_data_out[69] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1659 la_data_in[69] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1660 la_oenb[68] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1661 la_data_out[68] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1662 la_data_in[68] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1663 la_oenb[67] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1664 la_data_out[67] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1665 la_data_in[67] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1666 la_oenb[66] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1667 la_data_out[66] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1668 la_data_in[66] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1669 la_oenb[65] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1670 la_data_out[65] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1671 la_data_in[65] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1672 la_oenb[64] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1673 la_data_out[64] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1674 la_data_in[64] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1675 la_oenb[63] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1676 la_data_out[63] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1677 la_data_in[63] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1678 la_oenb[62] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1679 la_data_out[62] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1680 la_data_in[62] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1681 la_oenb[61] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1682 la_data_out[61] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1683 la_data_in[61] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1684 la_oenb[60] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1685 la_data_out[60] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1686 la_data_in[60] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1687 la_oenb[59] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1688 la_data_out[59] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1689 la_data_in[59] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1690 la_oenb[58] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1691 la_data_out[58] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1692 la_data_in[58] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1693 la_oenb[57] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1694 la_data_out[57] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1695 la_data_in[57] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1696 la_oenb[56] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1697 la_data_out[56] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1698 la_data_in[56] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1699 la_oenb[55] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1700 la_data_out[55] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1701 la_data_in[55] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1702 la_oenb[54] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1703 la_data_out[54] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1704 la_data_in[54] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1705 la_oenb[53] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1706 la_data_out[53] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1707 la_data_in[53] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1708 la_oenb[52] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1709 la_data_out[52] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1710 la_data_in[52] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1711 la_oenb[51] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1712 la_data_out[51] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1713 la_data_in[51] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1714 la_oenb[50] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1715 la_data_out[50] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1716 la_data_in[50] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1717 la_oenb[49] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1718 la_data_out[49] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1719 la_data_in[49] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1720 la_oenb[48] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1721 la_data_out[48] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1722 la_data_in[48] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1723 la_oenb[47] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1724 la_data_out[47] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1725 la_data_in[47] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1726 la_oenb[46] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1727 la_data_out[46] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1728 la_data_in[46] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1729 la_oenb[45] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1730 la_data_out[45] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1731 la_data_in[45] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1732 la_oenb[44] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1733 la_data_out[44] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1734 la_data_in[44] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1735 la_oenb[43] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1736 la_data_out[43] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1737 la_data_in[43] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1738 la_oenb[42] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1739 la_data_out[42] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1740 la_data_in[42] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1741 la_oenb[41] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1742 la_data_out[41] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1743 la_data_in[41] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1744 la_oenb[40] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1745 la_data_out[40] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1746 la_data_in[40] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1747 la_oenb[39] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1748 la_data_out[39] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1749 la_data_in[39] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1750 la_oenb[38] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1751 la_data_out[38] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1752 la_data_in[38] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1753 la_oenb[37] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1754 la_data_out[37] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1755 la_data_in[37] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1756 la_oenb[36] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1757 la_data_out[36] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1758 la_data_in[36] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1759 la_oenb[35] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1760 la_data_out[35] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1761 la_data_in[35] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1762 la_oenb[34] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1763 la_data_out[34] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1764 la_data_in[34] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1765 la_oenb[33] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1766 la_data_out[33] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1767 la_data_in[33] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1768 la_oenb[32] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1769 la_data_out[32] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1770 la_data_in[32] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1771 la_oenb[31] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1772 la_data_out[31] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1773 la_data_in[31] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1774 la_oenb[30] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1775 la_data_out[30] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1776 la_data_in[30] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1777 la_oenb[29] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1778 la_data_out[29] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1779 la_data_in[29] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1780 la_oenb[28] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1781 la_data_out[28] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1782 la_data_in[28] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1783 la_oenb[27] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1784 la_data_out[27] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1785 la_data_in[27] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1786 la_oenb[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1787 la_data_out[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1788 la_data_in[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1789 la_oenb[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1790 la_data_out[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1791 la_data_in[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1792 la_oenb[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1793 la_data_out[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1794 la_data_in[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1795 la_oenb[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1796 la_data_out[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1797 la_data_in[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1798 la_oenb[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1799 la_data_out[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1800 la_data_in[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1801 la_oenb[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1802 la_data_out[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1803 la_data_in[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1804 la_oenb[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1805 la_data_out[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1806 la_data_in[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1807 la_oenb[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1808 la_data_out[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1809 la_data_in[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1810 la_oenb[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1811 la_data_out[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1812 la_data_in[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1813 la_oenb[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1814 la_data_out[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1815 la_data_in[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1816 la_oenb[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1817 la_data_out[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1818 la_data_in[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1819 la_oenb[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1820 la_data_out[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1821 la_data_in[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1822 la_oenb[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1823 la_data_out[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1824 la_data_in[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1825 la_oenb[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1826 la_data_out[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1827 la_data_in[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1828 la_oenb[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1829 la_data_out[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1830 la_data_in[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1831 la_oenb[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1832 la_data_out[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1833 la_data_in[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1834 la_oenb[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1835 la_data_out[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1836 la_data_in[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1837 la_oenb[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1838 la_data_out[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1839 la_data_in[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1840 la_oenb[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1841 la_data_out[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1842 la_data_in[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1843 la_oenb[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1844 la_data_out[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1845 la_data_in[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1846 la_oenb[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1847 la_data_out[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1848 la_data_in[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1849 la_oenb[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1850 la_data_out[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1851 la_data_in[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1852 la_oenb[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1853 la_data_out[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1854 la_data_in[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1855 la_oenb[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1856 la_data_out[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1857 la_data_in[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1858 la_oenb[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1859 la_data_out[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1860 la_data_in[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1861 la_oenb[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1862 la_data_out[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1863 la_data_in[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1864 la_oenb[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1865 la_data_out[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1866 la_data_in[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1867 wbs_dat_o[31] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1868 wbs_dat_i[31] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1869 wbs_adr_i[31] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1870 wbs_dat_o[30] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1871 wbs_dat_i[30] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1872 wbs_adr_i[30] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1873 wbs_dat_o[29] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1874 wbs_dat_i[29] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1875 wbs_adr_i[29] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1876 wbs_dat_o[28] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1877 wbs_dat_i[28] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1878 wbs_adr_i[28] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1879 wbs_dat_o[27] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1880 wbs_dat_i[27] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1881 wbs_adr_i[27] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1882 wbs_dat_o[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1883 wbs_dat_i[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1884 wbs_adr_i[26] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1885 wbs_dat_o[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1886 wbs_dat_i[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1887 wbs_adr_i[25] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1888 wbs_dat_o[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1889 wbs_dat_i[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1890 wbs_adr_i[24] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1891 wbs_dat_o[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1892 wbs_dat_i[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1893 wbs_adr_i[23] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1894 wbs_dat_o[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1895 wbs_dat_i[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1896 wbs_adr_i[22] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1897 wbs_dat_o[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1898 wbs_dat_i[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1899 wbs_adr_i[21] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1900 wbs_dat_o[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1901 wbs_dat_i[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1902 wbs_adr_i[20] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1903 wbs_dat_o[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1904 wbs_dat_i[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1905 wbs_adr_i[19] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1906 wbs_dat_o[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1907 wbs_dat_i[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1908 wbs_adr_i[18] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1909 wbs_dat_o[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1910 wbs_dat_i[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1911 wbs_adr_i[17] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1912 wbs_dat_o[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1913 wbs_dat_i[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1914 wbs_adr_i[16] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1915 wbs_dat_o[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1916 wbs_dat_i[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1917 wbs_adr_i[15] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1918 wbs_dat_o[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1919 wbs_dat_i[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1920 wbs_adr_i[14] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1921 wbs_dat_o[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1922 wbs_dat_i[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1923 wbs_adr_i[13] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1924 wbs_dat_o[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1925 wbs_dat_i[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1926 wbs_adr_i[12] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1927 wbs_dat_o[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1928 wbs_dat_i[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1929 wbs_adr_i[11] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1930 wbs_dat_o[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1931 wbs_dat_i[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1932 wbs_adr_i[10] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1933 wbs_dat_o[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1934 wbs_dat_i[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1935 wbs_adr_i[9] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1936 wbs_dat_o[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1937 wbs_dat_i[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1938 wbs_adr_i[8] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1939 wbs_dat_o[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1940 wbs_dat_i[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1941 wbs_adr_i[7] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1942 wbs_dat_o[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1943 wbs_dat_i[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1944 wbs_adr_i[6] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1945 wbs_dat_o[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1946 wbs_dat_i[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1947 wbs_adr_i[5] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1948 wbs_dat_o[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1949 wbs_dat_i[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1950 wbs_adr_i[4] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1951 wbs_sel_i[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1952 wbs_dat_o[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1953 wbs_dat_i[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1954 wbs_adr_i[3] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1955 wbs_sel_i[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1956 wbs_dat_o[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1957 wbs_dat_i[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1958 wbs_adr_i[2] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1959 wbs_sel_i[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1960 wbs_dat_o[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1961 wbs_dat_i[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1962 wbs_adr_i[1] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1963 wbs_sel_i[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1964 wbs_dat_o[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1965 wbs_dat_i[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1966 wbs_adr_i[0] pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1967 wbs_we_i pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1968 wbs_stb_i pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1969 wbs_cyc_i pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1970 wbs_ack_o pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1971 wb_rst_i pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1972 wb_clk_i pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.63fF
C1973 pll_full_0/divider_0/and_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.65fF
C1974 pll_full_0/divider_0/and_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.45fF
C1975 pll_full_0/divider_0/and_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.35fF
C1976 pll_full_0/divider_0/and_0/out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.99fF
C1977 pll_full_0/divider_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C1978 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C1979 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C1980 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C1981 pll_full_0/divider_0/nor_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.08fF
C1982 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C1983 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C1984 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C1985 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C1986 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C1987 pll_full_0/divider_0/nor_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.12fF
C1988 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C1989 pll_full_0/divider_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.14fF
C1990 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C1991 pll_full_0/divbuf_0/IN pll_full_0/ro_complete_0/ro_var_extend_0/vdd 9.84fF
C1992 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C1993 pll_full_0/divider_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C1994 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C1995 pll_full_0/divider_0/nor_1/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.48fF
C1996 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C1997 pll_full_0/divider_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C1998 pll_full_0/divider_0/clk pll_full_0/ro_complete_0/ro_var_extend_0/vdd 33.42fF
C1999 pll_full_0/divider_0/prescaler_0/nand_1/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2000 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.64fF
C2001 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.72fF
C2002 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.61fF
C2003 pll_full_0/divider_0/prescaler_0/nand_0/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2004 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2005 pll_full_0/divider_0/and_0/OUT pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.67fF
C2006 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2007 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2008 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.19fF
C2009 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2010 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.47fF **FLOATING
C2011 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2012 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2013 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2014 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.48fF
C2015 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2016 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2017 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.22fF **FLOATING
C2018 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2019 pll_full_0/divider_0/prescaler_0/Out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.59fF
C2020 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2021 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2022 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2023 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.16fF **FLOATING
C2024 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2025 pll_full_0/divider_0/nor_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2026 pll_full_0/divider_0/nor_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2027 pll_full_0/divbuf_1/OUT pll_full_0/ro_complete_0/ro_var_extend_0/vdd 363.82fF
C2028 pll_full_0/divbuf_1/OUT5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 350.37fF
C2029 pll_full_0/divbuf_1/OUT4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 133.72fF
C2030 pll_full_0/divbuf_1/OUT3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 34.03fF
C2031 pll_full_0/divbuf_1/OUT2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 8.71fF
C2032 pll_full_0/divbuf_1/a_492_n240# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.46fF **FLOATING
C2033 pll_full_0/divbuf_0/OUT5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 350.37fF
C2034 pll_full_0/divbuf_0/OUT4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 133.72fF
C2035 pll_full_0/divbuf_0/OUT3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 34.03fF
C2036 pll_full_0/divbuf_0/OUT2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 8.71fF
C2037 pll_full_0/divbuf_0/a_492_n240# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.46fF **FLOATING
C2038 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/ro_complete_0/ro_var_extend_0/vdd 16.43fF
C2039 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.78fF
C2040 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2041 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.30fF
C2042 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.56fF
C2043 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF
C2044 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.02fF
C2045 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.78fF
C2046 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.35fF
C2047 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2048 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.54fF
C2049 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.30fF
C2050 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.96fF
C2051 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.56fF
C2052 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.21fF
C2053 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF
C2054 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.81fF
C2055 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.02fF
C2056 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.74fF
C2057 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/ro_var_extend_0/vdd 15.12fF
C2058 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.78fF
C2059 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2060 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.30fF
C2061 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.56fF
C2062 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF
C2063 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.02fF
C2064 pll_full_0/ro_complete_0/ro_var_extend_0/vcont pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.27fF
C2065 pll_full_0/filter_0/a_4216_n5230# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 418.90fF **FLOATING
C2066 pll_full_0/filter_0/a_4216_n2998# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.39fF **FLOATING
C2067 pll_full_0/cp_0/down pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.54fF
C2068 pll_full_0/cp_0/upbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.79fF
C2069 pll_full_0/cp_0/a_7110_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.17fF **FLOATING
C2070 pll_full_0/cp_0/a_3060_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.71fF **FLOATING
C2071 pll_full_0/cp_0/a_7110_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.17fF **FLOATING
C2072 pll_full_0/cp_0/a_6370_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.40fF **FLOATING
C2073 pll_full_0/cp_0/a_3060_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.49fF **FLOATING
C2074 pll_full_0/cp_0/a_1710_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.47fF **FLOATING
C2075 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.39fF
C2076 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.22fF
C2077 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2078 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2079 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.88fF
C2080 pll_full_0/pd_0/tspc_r_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2081 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2082 pll_full_0/pd_0/UP pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.41fF
C2083 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2084 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2085 pll_full_0/pd_0/REF pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.48fF
C2086 pll_full_0/pd_0/tspc_r_0/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2087 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2088 pll_full_0/pd_0/R pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.05fF
C2089 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.79fF
C2090 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2091 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2092 pll_full_0/pd_0/DOWN pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.34fF
C2093 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2094 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2095 pll_full_0/pd_0/DIV pll_full_0/ro_complete_0/ro_var_extend_0/vdd 372.47fF
C2096 pll_full_1/divider_0/and_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.65fF
C2097 pll_full_1/divider_0/and_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.45fF
C2098 pll_full_1/divider_0/and_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.35fF
C2099 pll_full_1/divider_0/and_0/out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.99fF
C2100 pll_full_1/divider_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2101 pll_full_1/divider_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2102 pll_full_1/divider_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2103 pll_full_1/divider_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2104 pll_full_1/divider_0/nor_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.08fF
C2105 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C2106 pll_full_1/divider_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2107 pll_full_1/divider_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2108 pll_full_1/divider_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2109 pll_full_1/divider_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2110 pll_full_1/divider_0/nor_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.12fF
C2111 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C2112 pll_full_1/divider_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.14fF
C2113 pll_full_1/divider_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2114 pll_full_1/divbuf_0/IN pll_full_0/ro_complete_0/ro_var_extend_0/vdd 9.84fF
C2115 pll_full_1/divider_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2116 pll_full_1/divider_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2117 pll_full_1/divider_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2118 pll_full_1/divider_0/nor_1/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.48fF
C2119 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2120 pll_full_1/divider_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2121 pll_full_1/divider_0/clk pll_full_0/ro_complete_0/ro_var_extend_0/vdd 33.42fF
C2122 pll_full_1/divider_0/prescaler_0/nand_1/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2123 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.64fF
C2124 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.72fF
C2125 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.61fF
C2126 pll_full_1/divider_0/prescaler_0/nand_0/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2127 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2128 pll_full_1/divider_0/and_0/OUT pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.67fF
C2129 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2130 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2131 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.19fF
C2132 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2133 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.47fF **FLOATING
C2134 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2135 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2136 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2137 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.48fF
C2138 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2139 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2140 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.22fF **FLOATING
C2141 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2142 pll_full_1/divider_0/prescaler_0/Out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.59fF
C2143 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2144 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2145 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2146 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.16fF **FLOATING
C2147 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2148 pll_full_1/divider_0/nor_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2149 pll_full_1/divider_0/nor_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2150 pll_full_1/divbuf_1/OUT pll_full_0/ro_complete_0/ro_var_extend_0/vdd 363.82fF
C2151 pll_full_1/divbuf_1/OUT5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 350.37fF
C2152 pll_full_1/divbuf_1/OUT4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 133.72fF
C2153 pll_full_1/divbuf_1/OUT3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 34.03fF
C2154 pll_full_1/divbuf_1/OUT2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 8.71fF
C2155 pll_full_1/divbuf_1/a_492_n240# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.46fF **FLOATING
C2156 pll_full_1/divbuf_0/OUT5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 350.37fF
C2157 pll_full_1/divbuf_0/OUT4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 133.72fF
C2158 pll_full_1/divbuf_0/OUT3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 34.03fF
C2159 pll_full_1/divbuf_0/OUT2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 8.71fF
C2160 pll_full_1/divbuf_0/a_492_n240# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.46fF **FLOATING
C2161 pll_full_1/ro_complete_0/cbank_2/v pll_full_0/ro_complete_0/ro_var_extend_0/vdd 16.43fF
C2162 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.78fF
C2163 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2164 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.30fF
C2165 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.56fF
C2166 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF
C2167 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.02fF
C2168 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.78fF
C2169 pll_full_1/ro_complete_0/a0 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.35fF
C2170 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2171 pll_full_1/ro_complete_0/a1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.54fF
C2172 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.30fF
C2173 pll_full_1/ro_complete_0/a3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.96fF
C2174 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.56fF
C2175 pll_full_1/ro_complete_0/a2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.21fF
C2176 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF
C2177 pll_full_1/ro_complete_0/a4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.81fF
C2178 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.02fF
C2179 pll_full_1/ro_complete_0/a5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.74fF
C2180 pll_full_1/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/ro_var_extend_0/vdd 15.12fF
C2181 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.78fF
C2182 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2183 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.30fF
C2184 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.56fF
C2185 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF
C2186 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.02fF
C2187 pll_full_1/ro_complete_0/ro_var_extend_0/vcont pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.27fF
C2188 pll_full_1/filter_0/a_4216_n5230# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 418.90fF **FLOATING
C2189 pll_full_1/filter_0/a_4216_n2998# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.39fF **FLOATING
C2190 pll_full_1/cp_0/down pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.54fF
C2191 pll_full_1/cp_0/upbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.79fF
C2192 pll_full_1/cp_0/a_7110_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.17fF **FLOATING
C2193 pll_full_1/cp_0/a_3060_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.71fF **FLOATING
C2194 pll_full_1/cp_0/a_7110_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.17fF **FLOATING
C2195 pll_full_1/cp_0/a_6370_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.40fF **FLOATING
C2196 pll_full_1/cp_0/a_3060_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.49fF **FLOATING
C2197 pll_full_1/cp_0/a_1710_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.47fF **FLOATING
C2198 pll_full_1/pd_0/and_pd_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.39fF
C2199 pll_full_1/pd_0/and_pd_0/Out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.22fF
C2200 pll_full_1/pd_0/tspc_r_1/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2201 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2202 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.88fF
C2203 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2204 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2205 pll_full_1/pd_0/UP pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.41fF
C2206 pll_full_1/pd_0/tspc_r_1/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2207 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2208 pll_full_1/pd_0/REF pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.48fF
C2209 pll_full_1/pd_0/tspc_r_0/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2210 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2211 pll_full_1/pd_0/R pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.05fF
C2212 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.79fF
C2213 pll_full_1/pd_0/tspc_r_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2214 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2215 pll_full_1/pd_0/DOWN pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.34fF
C2216 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2217 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2218 pll_full_1/pd_0/DIV pll_full_0/ro_complete_0/ro_var_extend_0/vdd 372.47fF
C2219 divider_1/and_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.74fF
C2220 divider_1/and_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.25fF
C2221 divider_1/and_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.19fF
C2222 divider_1/and_0/out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.93fF
C2223 divider_1/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2224 divider_1/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2225 divider_1/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2226 divider_1/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2227 divider_1/nor_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.04fF
C2228 divider_1/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C2229 divider_1/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2230 divider_1/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2231 divider_1/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2232 divider_1/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2233 divider_1/nor_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.05fF
C2234 divider_1/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C2235 divider_1/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.14fF
C2236 divider_1/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2237 divider_1/Out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.60fF
C2238 divider_1/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2239 divider_1/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2240 divider_1/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2241 divider_1/nor_1/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.33fF
C2242 divider_1/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2243 divider_1/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2244 divider_1/clk pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.63fF
C2245 divider_1/prescaler_0/nand_1/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2246 divider_1/prescaler_0/tspc_0/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.64fF
C2247 divider_1/prescaler_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.64fF
C2248 divider_1/prescaler_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.61fF
C2249 divider_1/prescaler_0/nand_0/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2250 divider_1/prescaler_0/tspc_2/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2251 divider_1/and_0/OUT pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.62fF
C2252 divider_1/prescaler_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2253 divider_1/prescaler_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2254 divider_1/prescaler_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2255 divider_1/prescaler_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2256 divider_1/prescaler_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2257 divider_1/prescaler_0/tspc_2/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2258 divider_1/prescaler_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2259 divider_1/prescaler_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2260 divider_1/prescaler_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.48fF
C2261 divider_1/prescaler_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2262 divider_1/prescaler_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2263 divider_1/prescaler_0/m1_2700_2190# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.22fF **FLOATING
C2264 divider_1/prescaler_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2265 divider_1/prescaler_0/Out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.59fF
C2266 divider_1/prescaler_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2267 divider_1/prescaler_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2268 divider_1/prescaler_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2269 divider_1/prescaler_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.16fF **FLOATING
C2270 divider_1/prescaler_0/tspc_0/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2271 divider_1/nor_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2272 divider_1/mc2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.29fF
C2273 divider_1/nor_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2274 divider_0/and_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.74fF
C2275 divider_0/and_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.25fF
C2276 divider_0/and_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.19fF
C2277 divider_0/and_0/out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.93fF
C2278 divider_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2279 divider_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2280 divider_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2281 divider_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2282 divider_0/nor_0/A pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.04fF
C2283 divider_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C2284 divider_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2285 divider_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2286 divider_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2287 divider_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2288 divider_0/nor_0/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 7.05fF
C2289 divider_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.15fF **FLOATING
C2290 divider_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.14fF
C2291 divider_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2292 divider_0/Out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.60fF
C2293 divider_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2294 divider_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2295 divider_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2296 divider_0/nor_1/B pll_full_0/ro_complete_0/ro_var_extend_0/vdd 6.33fF
C2297 divider_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2298 divider_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2299 divider_0/clk pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.63fF
C2300 divider_0/prescaler_0/nand_1/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2301 divider_0/prescaler_0/tspc_0/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.64fF
C2302 divider_0/prescaler_0/tspc_2/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.64fF
C2303 divider_0/prescaler_0/tspc_1/Q pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.61fF
C2304 divider_0/prescaler_0/nand_0/z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.36fF
C2305 divider_0/prescaler_0/tspc_2/D pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.12fF
C2306 divider_0/and_0/OUT pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.62fF
C2307 divider_0/prescaler_0/tspc_2/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2308 divider_0/prescaler_0/tspc_2/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2309 divider_0/prescaler_0/tspc_2/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2310 divider_0/prescaler_0/tspc_2/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2311 divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2312 divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2313 divider_0/prescaler_0/tspc_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2314 divider_0/prescaler_0/tspc_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2315 divider_0/prescaler_0/tspc_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.48fF
C2316 divider_0/prescaler_0/tspc_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2317 divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.14fF **FLOATING
C2318 divider_0/prescaler_0/m1_2700_2190# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.22fF **FLOATING
C2319 divider_0/prescaler_0/tspc_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.86fF
C2320 divider_0/prescaler_0/Out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.59fF
C2321 divider_0/prescaler_0/tspc_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.26fF
C2322 divider_0/prescaler_0/tspc_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.46fF
C2323 divider_0/prescaler_0/tspc_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.99fF
C2324 divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.16fF **FLOATING
C2325 divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.11fF **FLOATING
C2326 divider_0/nor_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2327 divider_0/mc2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.29fF
C2328 divider_0/nor_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2329 cp_0/down pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.54fF
C2330 cp_0/vbias pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.41fF
C2331 cp_0/out pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.26fF
C2332 cp_0/upbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.50fF
C2333 cp_0/a_7110_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.17fF **FLOATING
C2334 cp_0/a_3060_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.71fF **FLOATING
C2335 cp_0/a_7110_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.17fF **FLOATING
C2336 cp_0/a_6370_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.40fF **FLOATING
C2337 cp_0/a_3060_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.65fF **FLOATING
C2338 cp_0/a_1710_0# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 5.76fF **FLOATING
C2339 cp_0/a_1710_n2840# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 4.89fF **FLOATING
C2340 cp_0/a_10_n50# pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.96fF **FLOATING
C2341 pd_1/and_pd_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.39fF
C2342 pd_1/and_pd_0/Out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.22fF
C2343 pd_1/tspc_r_1/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2344 pd_1/tspc_r_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2345 pd_1/tspc_r_1/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.88fF
C2346 pd_1/tspc_r_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2347 pd_1/tspc_r_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2348 pd_1/UP pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.21fF
C2349 pd_1/tspc_r_1/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2350 pd_1/tspc_r_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2351 pd_1/REF pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.80fF
C2352 pd_1/tspc_r_0/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2353 pd_1/tspc_r_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2354 pd_1/R pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.05fF
C2355 pd_1/tspc_r_0/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.79fF
C2356 pd_1/tspc_r_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2357 pd_1/tspc_r_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2358 pd_1/DOWN pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.08fF
C2359 pd_1/tspc_r_0/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2360 pd_1/tspc_r_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2361 pd_1/DIV pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.82fF
C2362 pd_0/and_pd_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.39fF
C2363 pd_0/and_pd_0/Out1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.22fF
C2364 pd_0/tspc_r_1/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2365 pd_0/tspc_r_1/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2366 pd_0/tspc_r_1/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.88fF
C2367 pd_0/tspc_r_1/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2368 pd_0/tspc_r_1/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2369 pd_0/UP pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.21fF
C2370 pd_0/tspc_r_1/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2371 pd_0/tspc_r_1/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2372 pd_0/REF pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.80fF
C2373 pd_0/tspc_r_0/z5 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.10fF
C2374 pd_0/tspc_r_0/Z4 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.07fF
C2375 pd_0/R pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.05fF
C2376 pd_0/tspc_r_0/Qbar pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.79fF
C2377 pd_0/tspc_r_0/Z2 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.22fF
C2378 pd_0/tspc_r_0/Z1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 0.67fF
C2379 pd_0/DOWN pll_full_0/ro_complete_0/ro_var_extend_0/vdd 3.08fF
C2380 pd_0/tspc_r_0/Qbar1 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.34fF
C2381 pd_0/tspc_r_0/Z3 pll_full_0/ro_complete_0/ro_var_extend_0/vdd 2.12fF
C2382 pd_0/DIV pll_full_0/ro_complete_0/ro_var_extend_0/vdd 1.82fF
.ends
