* SPICE3 file created from user_analog_project_wrapper.ext - technology: sky130A

.subckt user_analog_project_wrapper gpio_analog[0] gpio_analog[10] gpio_analog[11]
+ gpio_analog[12] gpio_analog[13] gpio_analog[14] gpio_analog[15] gpio_analog[16]
+ gpio_analog[17] gpio_analog[1] gpio_analog[2] gpio_analog[3] gpio_analog[4] gpio_analog[5]
+ gpio_analog[6] gpio_analog[7] gpio_analog[8] gpio_analog[9] gpio_noesd[0] gpio_noesd[10]
+ gpio_noesd[11] gpio_noesd[12] gpio_noesd[13] gpio_noesd[14] gpio_noesd[15] gpio_noesd[16]
+ gpio_noesd[17] gpio_noesd[1] gpio_noesd[2] gpio_noesd[3] gpio_noesd[4] gpio_noesd[5]
+ gpio_noesd[6] gpio_noesd[7] gpio_noesd[8] gpio_noesd[9] io_analog[0] io_analog[10]
+ io_analog[1] io_analog[2] io_analog[3] io_analog[4] io_analog[5] io_analog[6] io_analog[7]
+ io_analog[8] io_analog[9] io_clamp_high[0] io_clamp_high[1] io_clamp_high[2] io_clamp_low[0]
+ io_clamp_low[1] io_clamp_low[2] io_in[0] io_in[10] io_in[11] io_in[12] io_in[13]
+ io_in[14] io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21]
+ io_in[22] io_in[23] io_in[24] io_in[25] io_in[26] io_in[2] io_in[3] io_in[4] io_in[5]
+ io_in[6] io_in[7] io_in[8] io_in[9] io_in_3v3[0] io_in_3v3[10] io_in_3v3[11] io_in_3v3[12]
+ io_in_3v3[13] io_in_3v3[14] io_in_3v3[15] io_in_3v3[16] io_in_3v3[17] io_in_3v3[18]
+ io_in_3v3[19] io_in_3v3[1] io_in_3v3[20] io_in_3v3[21] io_in_3v3[22] io_in_3v3[23]
+ io_in_3v3[24] io_in_3v3[25] io_in_3v3[26] io_in_3v3[2] io_in_3v3[3] io_in_3v3[4]
+ io_in_3v3[5] io_in_3v3[6] io_in_3v3[7] io_in_3v3[8] io_in_3v3[9] io_oeb[0] io_oeb[10]
+ io_oeb[11] io_oeb[12] io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18]
+ io_oeb[19] io_oeb[1] io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25]
+ io_oeb[26] io_oeb[2] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7] io_oeb[8]
+ io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14] io_out[15]
+ io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21] io_out[22]
+ io_out[23] io_out[24] io_out[25] io_out[26] io_out[2] io_out[3] io_out[4] io_out[5]
+ io_out[6] io_out[7] io_out[8] io_out[9] la_data_in[0] la_data_in[100] la_data_in[101]
+ la_data_in[102] la_data_in[103] la_data_in[104] la_data_in[105] la_data_in[106]
+ la_data_in[107] la_data_in[108] la_data_in[109] la_data_in[10] la_data_in[110] la_data_in[111]
+ la_data_in[112] la_data_in[113] la_data_in[114] la_data_in[115] la_data_in[116]
+ la_data_in[117] la_data_in[118] la_data_in[119] la_data_in[11] la_data_in[120] la_data_in[121]
+ la_data_in[122] la_data_in[123] la_data_in[124] la_data_in[125] la_data_in[126]
+ la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14] la_data_in[15] la_data_in[16]
+ la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1] la_data_in[20] la_data_in[21]
+ la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25] la_data_in[26] la_data_in[27]
+ la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30] la_data_in[31] la_data_in[32]
+ la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36] la_data_in[37] la_data_in[38]
+ la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41] la_data_in[42] la_data_in[43]
+ la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47] la_data_in[48] la_data_in[49]
+ la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52] la_data_in[53] la_data_in[54]
+ la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58] la_data_in[59] la_data_in[5]
+ la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63] la_data_in[64] la_data_in[65]
+ la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69] la_data_in[6] la_data_in[70]
+ la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74] la_data_in[75] la_data_in[76]
+ la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7] la_data_in[80] la_data_in[81]
+ la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85] la_data_in[86] la_data_in[87]
+ la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90] la_data_in[91] la_data_in[92]
+ la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96] la_data_in[97] la_data_in[98]
+ la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100] la_data_out[101] la_data_out[102]
+ la_data_out[103] la_data_out[104] la_data_out[105] la_data_out[106] la_data_out[107]
+ la_data_out[108] la_data_out[109] la_data_out[10] la_data_out[110] la_data_out[111]
+ la_data_out[112] la_data_out[113] la_data_out[114] la_data_out[115] la_data_out[116]
+ la_data_out[117] la_data_out[118] la_data_out[119] la_data_out[11] la_data_out[120]
+ la_data_out[121] la_data_out[122] la_data_out[123] la_data_out[124] la_data_out[125]
+ la_data_out[126] la_data_out[127] la_data_out[12] la_data_out[13] la_data_out[14]
+ la_data_out[15] la_data_out[16] la_data_out[17] la_data_out[18] la_data_out[19]
+ la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22] la_data_out[23] la_data_out[24]
+ la_data_out[25] la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34]
+ la_data_out[35] la_data_out[36] la_data_out[37] la_data_out[38] la_data_out[39]
+ la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42] la_data_out[43] la_data_out[44]
+ la_data_out[45] la_data_out[46] la_data_out[47] la_data_out[48] la_data_out[49]
+ la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52] la_data_out[53] la_data_out[54]
+ la_data_out[55] la_data_out[56] la_data_out[57] la_data_out[58] la_data_out[59]
+ la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62] la_data_out[63] la_data_out[64]
+ la_data_out[65] la_data_out[66] la_data_out[67] la_data_out[68] la_data_out[69]
+ la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72] la_data_out[73] la_data_out[74]
+ la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82] la_data_out[83] la_data_out[84]
+ la_data_out[85] la_data_out[86] la_data_out[87] la_data_out[88] la_data_out[89]
+ la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92] la_data_out[93] la_data_out[94]
+ la_data_out[95] la_data_out[96] la_data_out[97] la_data_out[98] la_data_out[99]
+ la_data_out[9] la_oenb[0] la_oenb[100] la_oenb[101] la_oenb[102] la_oenb[103] la_oenb[104]
+ la_oenb[105] la_oenb[106] la_oenb[107] la_oenb[108] la_oenb[109] la_oenb[10] la_oenb[110]
+ la_oenb[111] la_oenb[112] la_oenb[113] la_oenb[114] la_oenb[115] la_oenb[116] la_oenb[117]
+ la_oenb[118] la_oenb[119] la_oenb[11] la_oenb[120] la_oenb[121] la_oenb[122] la_oenb[123]
+ la_oenb[124] la_oenb[125] la_oenb[126] la_oenb[127] la_oenb[12] la_oenb[13] la_oenb[14]
+ la_oenb[15] la_oenb[16] la_oenb[17] la_oenb[18] la_oenb[19] la_oenb[1] la_oenb[20]
+ la_oenb[21] la_oenb[22] la_oenb[23] la_oenb[24] la_oenb[25] la_oenb[26] la_oenb[27]
+ la_oenb[28] la_oenb[29] la_oenb[2] la_oenb[30] la_oenb[31] la_oenb[32] la_oenb[33]
+ la_oenb[34] la_oenb[35] la_oenb[36] la_oenb[37] la_oenb[38] la_oenb[39] la_oenb[3]
+ la_oenb[40] la_oenb[41] la_oenb[42] la_oenb[43] la_oenb[44] la_oenb[45] la_oenb[46]
+ la_oenb[47] la_oenb[48] la_oenb[49] la_oenb[4] la_oenb[50] la_oenb[51] la_oenb[52]
+ la_oenb[53] la_oenb[54] la_oenb[55] la_oenb[56] la_oenb[57] la_oenb[58] la_oenb[59]
+ la_oenb[5] la_oenb[60] la_oenb[61] la_oenb[62] la_oenb[63] la_oenb[64] la_oenb[65]
+ la_oenb[66] la_oenb[67] la_oenb[68] la_oenb[69] la_oenb[6] la_oenb[70] la_oenb[71]
+ la_oenb[72] la_oenb[73] la_oenb[74] la_oenb[75] la_oenb[76] la_oenb[77] la_oenb[78]
+ la_oenb[79] la_oenb[7] la_oenb[80] la_oenb[81] la_oenb[82] la_oenb[83] la_oenb[84]
+ la_oenb[85] la_oenb[86] la_oenb[87] la_oenb[88] la_oenb[89] la_oenb[8] la_oenb[90]
+ la_oenb[91] la_oenb[92] la_oenb[93] la_oenb[94] la_oenb[95] la_oenb[96] la_oenb[97]
+ la_oenb[98] la_oenb[99] la_oenb[9] user_clock2 user_irq[0] user_irq[1] user_irq[2]
+ vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o wbs_adr_i[0]
+ wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14] wbs_adr_i[15]
+ wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1] wbs_adr_i[20]
+ wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25] wbs_adr_i[26]
+ wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30] wbs_adr_i[31]
+ wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8] wbs_adr_i[9]
+ wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13] wbs_dat_i[14]
+ wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19] wbs_dat_i[1]
+ wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24] wbs_dat_i[25]
+ wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2] wbs_dat_i[30]
+ wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6] wbs_dat_i[7] wbs_dat_i[8]
+ wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11] wbs_dat_o[12] wbs_dat_o[13]
+ wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17] wbs_dat_o[18] wbs_dat_o[19]
+ wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22] wbs_dat_o[23] wbs_dat_o[24]
+ wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28] wbs_dat_o[29] wbs_dat_o[2]
+ wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4] wbs_dat_o[5] wbs_dat_o[6]
+ wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1] wbs_sel_i[2] wbs_sel_i[3]
+ wbs_stb_i wbs_we_i
C0 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z4 0.08fF
C1 divider_1/mc2 divider_1/and_0/out1 0.06fF
C2 divider_0/prescaler_0/m1_2700_2190# divider_0/nor_0/A 0.01fF
C3 divider_0/prescaler_0/Out divider_0/tspc_2/Z4 0.12fF
C4 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Z4 0.65fF
C5 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/clk 0.01fF
C6 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/tspc_r_0/Qbar1 0.01fF
C7 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z2 0.14fF
C8 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_1/Q 0.01fF
C9 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C10 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/Out 0.05fF
C11 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/clk 0.60fF
C12 divider_1/tspc_0/Z2 divider_1/nor_0/B 0.20fF
C13 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z3 0.11fF
C14 pll_full_1/pd_0/tspc_r_0/Z1 pll_full_1/pd_0/tspc_r_0/Z2 0.71fF
C15 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/tspc_r_0/z5 0.20fF
C16 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.04fF
C17 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.22fF
C18 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/a_630_n680# 0.01fF
C19 divider_1/tspc_2/Z1 divider_1/tspc_2/Z3 0.06fF
C20 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z3 0.25fF
C21 pd_0/DOWN pd_0/UP 0.46fF
C22 pd_0/tspc_r_1/Z2 pd_0/tspc_r_1/Z4 0.14fF
C23 pll_full_1/filter_0/a_4216_n5230# pll_full_1/divider_0/clk 1.58fF
C24 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z1 0.03fF
C25 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/clk 0.12fF
C26 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_0/vin 0.19fF
C27 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/v 1.30fF
C28 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT 43.38fF
C29 ro_complete_1/a0 ro_complete_1/cbank_2/switch_5/vin 0.09fF
C30 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/REF 0.17fF
C31 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_0/B 0.51fF
C32 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C33 io_analog[5] io_clamp_low[1] 0.53fF
C34 divider_2/mc2 divider_2/nor_0/A 0.04fF
C35 divider_1/tspc_1/Z2 divider_1/tspc_1/Z4 0.36fF
C36 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z4 0.08fF
C37 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z3 0.05fF
C38 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z4 0.00fF
C39 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Out1 0.05fF
C40 divider_2/tspc_0/a_630_n680# divider_2/Out 0.04fF
C41 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z4 0.12fF
C42 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z1 0.09fF
C43 pd_1/REF pd_1/tspc_r_1/Z2 0.19fF
C44 pd_1/DOWN pd_1/tspc_r_0/z5 0.03fF
C45 divider_2/and_0/OUT divider_2/and_0/B 0.01fF
C46 io_clamp_low[0] io_clamp_high[0] 0.53fF
C47 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a4 0.12fF
C48 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C49 divider_0/tspc_2/Q divider_0/nor_0/A 0.55fF
C50 divider_0/tspc_1/Z2 divider_0/nor_0/B 0.30fF
C51 divider_0/tspc_0/a_630_n680# divider_0/nor_1/B 0.35fF
C52 divider_2/tspc_1/Q divider_2/tspc_1/a_630_n680# 0.04fF
C53 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z3 0.33fF
C54 divider_0/and_0/OUT divider_0/and_0/Z1 0.04fF
C55 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z2 0.01fF
C56 divider_0/prescaler_0/tspc_2/Q divider_0/clk 0.05fF
C57 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT5 0.01fF
C58 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C59 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C60 divider_1/prescaler_0/Out divider_1/clk 0.51fF
C61 pd_0/DOWN pd_0/R 0.36fF
C62 pd_0/tspc_r_0/Z1 pd_0/tspc_r_0/Z2 0.71fF
C63 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z4 0.20fF
C64 pd_0/DIV pd_0/tspc_r_0/z5 0.04fF
C65 pll_full_1/ro_complete_0/cbank_2/switch_0/vin pll_full_1/ro_complete_0/cbank_2/v 1.45fF
C66 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C67 divider_2/tspc_1/Z2 divider_2/nor_0/B 0.30fF
C68 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/a_630_n680# 0.19fF
C69 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Q 0.04fF
C70 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z2 0.11fF
C71 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C72 pll_full_1/ro_complete_0/cbank_2/v pll_full_1/divider_0/clk 1.36fF
C73 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/switch_1/vin 0.19fF
C74 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_4/vin 0.20fF
C75 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C76 divider_0/tspc_1/a_630_n680# divider_0/nor_1/B 0.00fF
C77 divider_0/mc2 divider_0/and_0/OUT 0.05fF
C78 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C79 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Z1 0.03fF
C80 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/clk 0.12fF
C81 divider_1/tspc_0/Z4 divider_1/nor_0/B 0.02fF
C82 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/nand_0/z1 0.07fF
C83 divider_0/and_0/out1 divider_0/and_0/B 0.18fF
C84 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C85 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C86 divider_2/nor_0/Z1 divider_2/and_0/B 0.18fF
C87 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z2 1.07fF
C88 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z2 1.07fF
C89 pd_0/tspc_r_0/Z4 pd_0/tspc_r_1/Z4 0.02fF
C90 pd_0/DOWN pd_0/and_pd_0/Out1 0.12fF
C91 pd_0/REF pd_0/tspc_r_1/Z1 0.17fF
C92 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_1/Q 0.45fF
C93 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C94 divider_2/prescaler_0/Out divider_2/tspc_2/Z3 0.45fF
C95 ro_complete_0/a4 ro_complete_0/cbank_1/v 0.05fF
C96 divider_0/tspc_2/Q divider_0/tspc_1/a_630_n680# 0.01fF
C97 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C98 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/a0 0.09fF
C99 divider_0/nor_0/B divider_0/tspc_2/a_630_n680# 0.01fF
C100 divider_0/tspc_1/Q divider_0/tspc_0/Z2 0.14fF
C101 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/Q 0.05fF
C102 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/R 0.02fF
C103 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C104 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C105 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z3 0.33fF
C106 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z2 0.16fF
C107 divider_1/prescaler_0/m1_2700_2190# divider_1/clk 0.01fF
C108 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z4 0.00fF
C109 pd_0/tspc_r_1/Z3 pd_0/UP 0.03fF
C110 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C111 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/A 0.80fF
C112 pll_full_1/ro_complete_0/cbank_1/switch_2/vin pll_full_1/divider_0/clk 1.46fF
C113 divider_2/prescaler_0/tspc_0/D divider_2/prescaler_0/nand_1/z1 0.21fF
C114 divider_2/nor_0/B divider_2/and_0/A 0.26fF
C115 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/Z1 0.04fF
C116 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z2 0.01fF
C117 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/clk 0.05fF
C118 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C119 ro_complete_1/cbank_1/v ro_complete_1/cbank_2/v 1.36fF
C120 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/IN 5.26fF
C121 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Qbar1 0.38fF
C122 pll_full_0/ro_complete_0/cbank_2/v pll_full_0/divider_0/clk 1.36fF
C123 divider_1/nor_1/B divider_1/Out 0.22fF
C124 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C125 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/IN 5.26fF
C126 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/nand_0/z1 0.07fF
C127 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Q 0.20fF
C128 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/D 0.09fF
C129 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_1/B 0.00fF
C130 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/nand_0/z1 0.07fF
C131 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.05fF
C132 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/B 0.18fF
C133 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/OUT2 0.02fF
C134 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a3 0.13fF
C135 divider_1/tspc_0/Z3 divider_1/Out 0.05fF
C136 divider_0/tspc_1/Z3 divider_0/tspc_1/Z4 0.65fF
C137 divider_0/prescaler_0/tspc_0/Z3 divider_0/clk 0.64fF
C138 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z4 0.14fF
C139 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/Out 0.19fF
C140 pll_full_1/pd_0/tspc_r_1/Z2 pll_full_1/pd_0/R 0.21fF
C141 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C142 pd_0/R pd_0/tspc_r_1/Z3 0.29fF
C143 divider_2/prescaler_0/m1_2700_2190# divider_2/clk 0.01fF
C144 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/tspc_0/D 0.04fF
C145 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/nand_1/z1 0.22fF
C146 pll_full_1/ro_complete_0/cbank_2/switch_5/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C147 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C148 divider_2/nor_0/B divider_2/tspc_1/Z4 0.21fF
C149 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z4 0.36fF
C150 pd_1/tspc_r_1/Qbar pd_1/UP 0.21fF
C151 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C152 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.05fF
C153 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/clk 0.01fF
C154 ro_complete_0/a5 ro_complete_0/cbank_1/switch_0/vin 0.09fF
C155 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/v 1.30fF
C156 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z1 0.06fF
C157 ro_complete_1/a1 ro_complete_1/cbank_1/v 0.05fF
C158 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/A 0.80fF
C159 pll_full_0/ro_complete_0/cbank_1/switch_2/vin pll_full_0/divider_0/clk 1.46fF
C160 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_0/B 0.18fF
C161 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z4 0.12fF
C162 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/Z1 0.04fF
C163 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/clk 0.05fF
C164 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Z4 0.28fF
C165 pll_full_0/divider_0/prescaler_0/tspc_2/Q pll_full_0/divider_0/prescaler_0/nand_1/z1 0.01fF
C166 pd_1/R pd_1/tspc_r_0/Z3 0.27fF
C167 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/Z4 0.00fF
C168 divider_1/tspc_2/Z1 divider_1/tspc_2/Z4 0.00fF
C169 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z3 0.06fF
C170 pll_full_0/pd_0/REF pll_full_0/divbuf_1/a_492_n240# 0.13fF
C171 ro_complete_0/a1 ro_complete_0/cbank_1/v 0.05fF
C172 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z2 0.01fF
C173 ro_complete_1/a0 ro_complete_1/cbank_2/v 0.05fF
C174 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C175 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_2/Q 0.19fF
C176 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/clk 0.01fF
C177 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/R 0.29fF
C178 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z3 0.65fF
C179 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_0/B 0.02fF
C180 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z4 0.15fF
C181 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C182 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/B 0.18fF
C183 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z4 0.65fF
C184 divider_1/prescaler_0/Out divider_1/prescaler_0/tspc_1/Q 0.91fF
C185 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z2 1.07fF
C186 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z4 0.12fF
C187 pll_full_0/divider_0/tspc_2/Z3 pll_full_0/divider_0/tspc_2/Z4 0.65fF
C188 cp_0/upbar cp_0/a_1710_n2840# 0.29fF
C189 pd_1/R pd_1/and_pd_0/Z1 0.02fF
C190 pll_full_1/pd_0/DIV pll_full_1/divider_0/clk 2.26fF
C191 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C192 ro_complete_0/a2 ro_complete_0/cbank_1/switch_3/vin 0.09fF
C193 divider_0/nor_0/Z1 divider_0/nor_0/B 0.06fF
C194 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C195 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z3 0.06fF
C196 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/clk 0.14fF
C197 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Z4 0.08fF
C198 divider_0/nor_0/A divider_0/tspc_2/Z2 0.23fF
C199 divider_0/prescaler_0/tspc_0/D divider_0/clk 0.29fF
C200 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/clk 0.01fF
C201 pll_full_1/divbuf_0/OUT4 pll_full_1/divbuf_0/OUT5 20.26fF
C202 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C203 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Qbar1 0.38fF
C204 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/Z3 0.05fF
C205 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.06fF
C206 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C207 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/z5 0.20fF
C208 divider_1/nor_1/Z1 divider_1/and_0/B 0.78fF
C209 cp_0/upbar cp_0/down 0.02fF
C210 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Out1 0.05fF
C211 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C212 ro_complete_0/a4 ro_complete_0/a3 2.71fF
C213 divider_2/and_0/out1 divider_2/and_0/A 0.01fF
C214 divider_2/tspc_2/Q divider_2/tspc_1/a_630_n680# 0.01fF
C215 ro_complete_1/a4 ro_complete_1/cbank_0/switch_1/vin 0.09fF
C216 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/a_740_n680# 0.33fF
C217 ro_complete_1/a3 ro_complete_1/cbank_2/switch_2/vin 0.09fF
C218 pll_full_0/divbuf_0/OUT2 pll_full_0/divbuf_0/a_492_n240# 0.42fF
C219 divider_1/mc2 divider_1/nor_0/A 0.04fF
C220 divider_0/nor_0/B divider_0/nor_1/B 0.47fF
C221 divider_0/prescaler_0/tspc_1/Z2 divider_0/and_0/OUT 0.06fF
C222 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z3 0.33fF
C223 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C224 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/Q 0.38fF
C225 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z3 0.05fF
C226 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C227 pd_1/R pd_1/tspc_r_0/Qbar1 0.01fF
C228 pd_1/tspc_r_0/Qbar pd_1/DOWN 0.21fF
C229 pd_0/tspc_r_0/z5 pd_0/tspc_r_1/z5 0.02fF
C230 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z2 0.25fF
C231 divider_2/nor_1/B divider_2/and_0/B 0.29fF
C232 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z4 0.65fF
C233 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C234 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C235 divider_2/prescaler_0/Out divider_2/tspc_2/Z4 0.12fF
C236 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.19fF
C237 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/clk 0.01fF
C238 ro_complete_0/a1 ro_complete_0/a0 2.98fF
C239 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/a_630_n680# 0.19fF
C240 ro_complete_0/a3 ro_complete_0/cbank_2/switch_2/vin 0.09fF
C241 divider_0/nor_0/Z1 divider_0/and_0/B 0.18fF
C242 divider_0/tspc_2/Q divider_0/nor_0/B 0.22fF
C243 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/v 1.30fF
C244 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C245 divider_0/tspc_0/Z4 divider_0/tspc_0/Z2 0.36fF
C246 divider_0/nor_0/B divider_0/nor_0/A 1.21fF
C247 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z4 0.15fF
C248 pll_full_0/divbuf_0/IN pll_full_0/divider_0/nor_1/B 0.27fF
C249 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C250 pll_full_0/divider_0/and_0/A pll_full_0/divider_0/and_0/B 0.18fF
C251 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Z4 0.08fF
C252 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C253 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C254 pd_1/REF pd_1/tspc_r_1/Z3 0.65fF
C255 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/nor_0/B 0.03fF
C256 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/a_630_n680# 0.05fF
C257 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/nor_1/B 0.35fF
C258 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C259 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C260 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a4 0.12fF
C261 divider_2/prescaler_0/tspc_1/Q divider_2/nor_0/A 0.03fF
C262 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z2 0.23fF
C263 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/clk 0.29fF
C264 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/v 1.30fF
C265 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C266 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/tspc_0/Z4 0.12fF
C267 divider_0/tspc_1/Q divider_0/tspc_0/Z4 0.15fF
C268 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_1/Q 0.13fF
C269 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z2 0.19fF
C270 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C271 divider_0/and_0/OUT divider_0/and_0/out1 0.31fF
C272 divider_0/nor_1/B divider_0/and_0/B 0.29fF
C273 pll_full_1/pd_0/UP pll_full_1/pd_0/and_pd_0/Out1 0.33fF
C274 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.91fF
C275 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C276 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/Q 0.38fF
C277 divider_2/mc2 divider_2/and_0/B 0.20fF
C278 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Q 0.04fF
C279 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/clk 0.01fF
C280 pd_0/DIV pd_0/tspc_r_0/Qbar1 0.12fF
C281 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/z5 0.20fF
C282 divider_2/prescaler_0/tspc_0/Z2 divider_2/and_0/OUT 0.06fF
C283 divider_2/nor_1/Z1 divider_2/and_0/B 0.78fF
C284 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_1/B 0.47fF
C285 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/and_0/OUT 0.06fF
C286 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C287 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.38fF
C288 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.11fF
C289 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_4/vin 0.20fF
C290 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT2 0.02fF
C291 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z2 0.01fF
C292 divider_0/tspc_1/a_630_n680# divider_0/nor_0/B 0.35fF
C293 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/clk 0.01fF
C294 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z3 0.06fF
C295 divider_0/nor_0/A divider_0/and_0/B 0.08fF
C296 pll_full_1/divbuf_1/a_492_n240# pll_full_1/divbuf_1/OUT2 0.42fF
C297 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C298 divider_1/nor_0/B divider_1/tspc_1/a_630_n680# 0.35fF
C299 divider_1/prescaler_0/tspc_2/Q divider_1/prescaler_0/nand_1/z1 0.01fF
C300 divider_1/prescaler_0/tspc_2/Z2 divider_1/clk 0.11fF
C301 pd_1/tspc_r_0/Z2 pd_1/R 0.21fF
C302 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z1 0.01fF
C303 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C304 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/nor_0/A 1.21fF
C305 divider_2/tspc_1/Q divider_2/tspc_0/Z3 0.45fF
C306 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/REF 0.02fF
C307 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C308 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Z4 0.01fF
C309 divider_0/prescaler_0/tspc_2/Z2 divider_0/and_0/OUT 0.05fF
C310 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar 0.21fF
C311 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C312 pll_full_0/pd_0/DIV pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.03fF
C313 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/clk 0.29fF
C314 pll_full_0/divider_0/prescaler_0/tspc_0/D pll_full_0/divider_0/prescaler_0/nand_1/z1 0.21fF
C315 divider_1/tspc_2/Z3 divider_1/tspc_2/Z4 0.65fF
C316 pd_1/R pd_1/tspc_r_1/Qbar1 0.30fF
C317 pll_full_1/pd_0/DIV pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.03fF
C318 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/divider_0/clk 1.46fF
C319 divider_2/tspc_1/Z2 divider_2/tspc_2/Q 0.14fF
C320 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/out1 0.31fF
C321 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/and_0/B 0.29fF
C322 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/a_492_n240# 0.01fF
C323 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_1/Q 0.15fF
C324 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/tspc_0/D 0.32fF
C325 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/clk 0.01fF
C326 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.15fF
C327 io_analog[4] io_clamp_high[0] 0.53fF
C328 divider_2/nor_1/B divider_2/tspc_0/Z1 0.03fF
C329 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z3 0.16fF
C330 divider_2/tspc_0/Z2 divider_2/tspc_0/Z1 1.07fF
C331 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z4 0.36fF
C332 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/nor_0/B 0.35fF
C333 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_1/B 0.22fF
C334 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a4 0.12fF
C335 ro_complete_0/a2 ro_complete_0/cbank_0/switch_3/vin 0.09fF
C336 divider_2/nor_0/A divider_2/tspc_2/Z1 0.03fF
C337 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z3 0.05fF
C338 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/B 0.08fF
C339 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z3 0.06fF
C340 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C341 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/a4 0.09fF
C342 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/a5 0.09fF
C343 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z4 0.00fF
C344 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z1 0.01fF
C345 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C346 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/a_630_n680# 0.01fF
C347 divider_0/tspc_2/Z1 divider_0/tspc_2/Z3 0.06fF
C348 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT2 1.37fF
C349 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C350 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/and_0/OUT 0.05fF
C351 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/a5 0.09fF
C352 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C353 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/a_630_n680# 0.05fF
C354 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/cbank_0/v 1.30fF
C355 divider_1/tspc_1/Q divider_1/nor_0/B 0.51fF
C356 divider_0/prescaler_0/Out divider_0/tspc_2/a_630_n680# 0.01fF
C357 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Z4 0.08fF
C358 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z3 0.05fF
C359 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/divider_0/clk 1.46fF
C360 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/DOWN 0.07fF
C361 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C362 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/and_0/B 0.29fF
C363 divider_1/nor_0/Z1 divider_1/and_0/B 0.18fF
C364 divider_1/tspc_0/a_630_n680# divider_1/Out 0.04fF
C365 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Z4 0.12fF
C366 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C367 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C368 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/Qbar 0.01fF
C369 divider_2/prescaler_0/tspc_0/Z3 divider_2/clk 0.64fF
C370 divider_1/and_0/OUT divider_1/and_0/B 0.01fF
C371 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C372 divider_2/tspc_1/Z2 divider_2/nor_0/A 0.15fF
C373 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/D 0.03fF
C374 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.32fF
C375 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/clk 0.01fF
C376 ro_complete_1/a4 ro_complete_1/cbank_2/switch_0/vin 0.12fF
C377 ro_complete_0/a5 ro_complete_0/cbank_1/v 0.10fF
C378 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/a0 0.09fF
C379 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z2 0.16fF
C380 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/IN 0.00fF
C381 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/B 0.08fF
C382 divider_1/tspc_1/Z2 divider_1/nor_0/B 0.30fF
C383 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/a_630_n680# 0.19fF
C384 divider_1/prescaler_0/tspc_1/a_630_n680# divider_1/prescaler_0/tspc_1/Q 0.04fF
C385 divider_2/tspc_0/Z4 divider_2/tspc_0/Z1 0.00fF
C386 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/Z4 0.36fF
C387 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/nor_0/B 0.38fF
C388 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.04fF
C389 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C390 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C391 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/divider_0/clk 1.46fF
C392 divider_2/tspc_1/Z4 divider_2/tspc_2/Q 0.15fF
C393 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z3 0.06fF
C394 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/a0 0.13fF
C395 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z3 0.05fF
C396 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/D 0.03fF
C397 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C398 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z2 1.07fF
C399 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z2 1.07fF
C400 pll_full_1/pd_0/REF pll_full_1/divbuf_1/a_492_n240# 0.13fF
C401 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C402 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.09fF
C403 pd_0/tspc_r_0/Z3 pd_0/DOWN 0.03fF
C404 divider_2/tspc_0/Z3 divider_2/Out 0.05fF
C405 divider_1/prescaler_0/Out divider_1/tspc_2/Z3 0.45fF
C406 divider_2/tspc_1/Z1 divider_2/tspc_1/Z2 1.07fF
C407 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C408 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C409 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.04fF
C410 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/and_pd_0/Z1 0.18fF
C411 divider_2/tspc_2/Z3 divider_2/tspc_2/Q 0.05fF
C412 divider_2/nor_0/A divider_2/and_0/A 0.01fF
C413 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a2 0.09fF
C414 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a3 0.13fF
C415 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT3 0.26fF
C416 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT4 20.26fF
C417 pll_full_0/ro_complete_0/cbank_0/switch_0/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C418 divider_0/prescaler_0/m1_2700_2190# divider_0/and_0/OUT 0.14fF
C419 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C420 pll_full_0/divbuf_0/IN pll_full_0/divider_0/tspc_0/a_630_n680# 0.04fF
C421 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/tspc_1/Z4 0.00fF
C422 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/clk 0.01fF
C423 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/a_492_n240# 0.01fF
C424 divider_1/prescaler_0/tspc_0/D divider_1/prescaler_0/nand_1/z1 0.21fF
C425 divider_1/nor_0/B divider_1/and_0/A 0.26fF
C426 pll_full_0/pd_0/R pll_full_0/pd_0/UP 0.46fF
C427 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z1 0.00fF
C428 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/v 1.30fF
C429 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/Out 0.21fF
C430 divider_0/tspc_0/Z3 divider_0/Out 0.05fF
C431 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_1/Z3 0.11fF
C432 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/divider_0/clk 1.46fF
C433 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/clk 0.01fF
C434 divider_1/mc2 divider_1/and_0/B 0.20fF
C435 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/Q 0.20fF
C436 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/D 0.09fF
C437 divider_0/prescaler_0/tspc_0/Z4 divider_0/clk 0.12fF
C438 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z2 1.07fF
C439 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C440 divider_2/mc2 divider_2/and_0/OUT 0.05fF
C441 divider_1/nor_1/B divider_1/and_0/B 0.29fF
C442 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C443 pll_full_1/cp_0/down pll_full_1/cp_0/upbar 0.02fF
C444 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/nor_0/A 0.03fF
C445 pd_1/tspc_r_0/Z1 pd_1/DIV 0.17fF
C446 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Q 0.05fF
C447 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C448 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_1/B 0.06fF
C449 divider_2/tspc_1/Z4 divider_2/nor_0/A 0.02fF
C450 divider_2/tspc_1/Z3 divider_2/tspc_1/a_630_n680# 0.05fF
C451 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C452 ro_complete_0/a0 ro_complete_0/cbank_2/switch_4/vin 0.13fF
C453 ro_complete_0/cbank_0/v ro_complete_0/cbank_1/v 1.27fF
C454 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/Z4 0.65fF
C455 divider_0/tspc_1/Z1 divider_0/tspc_1/Z2 1.07fF
C456 divider_0/prescaler_0/Out divider_0/prescaler_0/m1_2700_2190# 0.11fF
C457 ro_complete_1/cbank_2/switch_2/vin ro_complete_1/cbank_2/v 1.30fF
C458 pll_full_0/divbuf_0/a_492_n240# pll_full_0/divbuf_0/IN 0.13fF
C459 divider_1/nor_1/B divider_1/nor_1/Z1 0.06fF
C460 divider_0/nor_0/B divider_0/and_0/B 0.31fF
C461 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/tspc_0/D 0.04fF
C462 divider_0/prescaler_0/tspc_1/Q divider_0/prescaler_0/nand_1/z1 0.22fF
C463 divider_1/nor_0/B divider_1/tspc_1/Z4 0.21fF
C464 divider_1/prescaler_0/tspc_2/Z2 divider_1/prescaler_0/tspc_2/Z4 0.36fF
C465 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C466 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_1/B 0.22fF
C467 ro_complete_0/a2 ro_complete_0/cbank_2/switch_3/vin 0.09fF
C468 pll_full_0/pd_0/DOWN pll_full_0/pd_0/UP 4.58fF
C469 divider_2/nor_0/A divider_2/tspc_2/Z3 0.38fF
C470 divider_2/tspc_2/Z1 divider_2/tspc_2/Z2 1.07fF
C471 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z4 0.12fF
C472 ro_complete_1/a5 ro_complete_1/cbank_2/switch_0/vin 0.09fF
C473 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z3 0.16fF
C474 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/nor_0/B 0.06fF
C475 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z1 0.00fF
C476 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/Z4 0.00fF
C477 divider_0/tspc_2/Z1 divider_0/tspc_2/Z4 0.00fF
C478 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/A 0.15fF
C479 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z3 0.45fF
C480 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C481 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_1/Q 0.13fF
C482 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/OUT2 0.06fF
C483 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT3 0.01fF
C484 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divbuf_0/IN 0.05fF
C485 divider_2/tspc_1/Z1 divider_2/tspc_1/Z4 0.00fF
C486 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z2 0.01fF
C487 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.20fF
C488 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.09fF
C489 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/clk 0.11fF
C490 divider_2/and_0/out1 divider_2/and_0/Z1 0.36fF
C491 pll_full_0/ro_complete_0/cbank_1/switch_1/vin pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C492 divider_0/prescaler_0/Out divider_0/nor_0/A 0.15fF
C493 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z2 1.07fF
C494 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z4 0.12fF
C495 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/Out 0.04fF
C496 pd_0/tspc_r_1/Z1 pd_0/tspc_r_1/Z2 0.71fF
C497 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z4 0.20fF
C498 pd_0/REF pd_0/tspc_r_1/z5 0.04fF
C499 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z2 0.14fF
C500 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_1/Q 0.01fF
C501 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.36fF
C502 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/Out 0.05fF
C503 pll_full_1/ro_complete_0/a2 pll_full_1/divider_0/clk 0.11fF
C504 pd_1/and_pd_0/Z1 pd_1/UP 0.06fF
C505 pll_full_0/pd_0/tspc_r_0/Z1 pll_full_0/pd_0/tspc_r_0/Z3 0.09fF
C506 divider_2/and_0/OUT divider_2/prescaler_0/nand_0/z1 0.01fF
C507 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/B 0.31fF
C508 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/tspc_0/D 0.04fF
C509 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.22fF
C510 ro_complete_0/a2 ro_complete_0/cbank_2/v 0.05fF
C511 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_0/Z4 0.08fF
C512 divider_0/prescaler_0/tspc_1/Z2 divider_0/clk 0.11fF
C513 pll_full_0/divider_0/and_0/B pll_full_0/divider_0/and_0/Z1 0.07fF
C514 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C515 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C516 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/a_492_n240# 0.00fF
C517 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z1 0.03fF
C518 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z3 0.05fF
C519 divider_1/and_0/out1 divider_1/and_0/A 0.01fF
C520 divider_1/tspc_2/Q divider_1/tspc_1/a_630_n680# 0.01fF
C521 cp_0/a_1710_0# cp_0/a_10_n50# 0.04fF
C522 pd_1/DOWN pd_1/tspc_r_1/Qbar 0.02fF
C523 pd_0/tspc_r_1/Qbar pd_0/UP 0.21fF
C524 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/nor_0/B 0.51fF
C525 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.16fF
C526 pll_full_1/ro_complete_0/cbank_1/switch_0/vin pll_full_1/divider_0/clk 1.58fF
C527 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/switch_1/vin 0.19fF
C528 divider_2/and_0/OUT divider_2/clk 0.04fF
C529 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z4 0.00fF
C530 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C531 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C532 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/D 0.05fF
C533 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C534 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/clk 0.11fF
C535 divider_1/nor_1/B divider_1/tspc_0/Z1 0.03fF
C536 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a4 0.12fF
C537 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_3/vin 0.09fF
C538 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Qbar1 0.12fF
C539 divider_1/prescaler_0/Out divider_1/tspc_2/Z4 0.12fF
C540 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z1 0.09fF
C541 pd_0/DIV pd_0/tspc_r_0/Z2 0.19fF
C542 divider_2/tspc_1/Z2 divider_2/tspc_1/Z3 0.16fF
C543 ro_complete_0/a2 ro_complete_0/cbank_1/switch_2/vin 0.14fF
C544 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 1.07fF
C545 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.12fF
C546 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/v 1.30fF
C547 pll_full_0/ro_complete_0/a2 pll_full_0/divider_0/clk 0.11fF
C548 divider_1/tspc_0/Z3 divider_1/tspc_0/Z1 0.06fF
C549 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_1/Q 0.21fF
C550 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_2/D 0.16fF
C551 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C552 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/B 0.31fF
C553 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C554 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/D 0.03fF
C555 divider_1/prescaler_0/tspc_1/Q divider_1/nor_0/A 0.03fF
C556 pd_0/R pd_0/tspc_r_1/Qbar 0.03fF
C557 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.33fF
C558 divider_2/prescaler_0/Out divider_2/tspc_2/a_630_n680# 0.01fF
C559 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/D 0.15fF
C560 divider_2/prescaler_0/tspc_0/Z2 divider_2/clk 0.11fF
C561 pd_1/and_pd_0/Out1 pd_1/and_pd_0/Z1 0.18fF
C562 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/clk 0.11fF
C563 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/v 1.30fF
C564 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C565 pll_full_0/ro_complete_0/cbank_1/switch_0/vin pll_full_0/divider_0/clk 1.58fF
C566 divider_2/tspc_1/Q divider_2/nor_0/B 0.51fF
C567 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Q 0.04fF
C568 pll_full_1/pd_0/tspc_r_1/Z3 pll_full_1/pd_0/tspc_r_1/Z2 0.25fF
C569 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z3 0.16fF
C570 divider_2/nor_1/B divider_2/tspc_0/Z2 0.40fF
C571 divider_1/prescaler_0/tspc_0/Z2 divider_1/and_0/OUT 0.06fF
C572 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/a0 0.09fF
C573 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/UP 0.11fF
C574 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/Out 0.08fF
C575 pd_1/R pd_1/tspc_r_1/Z2 0.21fF
C576 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Out1 0.05fF
C577 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# 0.19fF
C578 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.11fF
C579 ro_complete_1/a4 ro_complete_1/cbank_1/v 0.05fF
C580 divider_0/tspc_1/Z2 divider_0/tspc_1/Z3 0.16fF
C581 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C582 divider_0/prescaler_0/tspc_0/Z2 divider_0/and_0/OUT 0.06fF
C583 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/switch_5/vin 0.20fF
C584 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z3 0.20fF
C585 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C586 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Qbar1 0.11fF
C587 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z2 0.01fF
C588 divider_0/prescaler_0/tspc_2/Q divider_0/prescaler_0/nand_1/z1 0.01fF
C589 divider_0/prescaler_0/tspc_2/Z2 divider_0/clk 0.11fF
C590 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z4 0.00fF
C591 divider_2/prescaler_0/tspc_1/Z2 divider_2/and_0/OUT 0.06fF
C592 pd_1/REF pd_1/tspc_r_1/Z4 0.02fF
C593 pd_1/DIV pd_1/tspc_r_0/Z4 0.02fF
C594 pd_0/and_pd_0/Z1 pd_0/UP 0.06fF
C595 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C596 pll_full_1/ro_complete_0/cbank_1/switch_5/vin pll_full_1/divider_0/clk 1.46fF
C597 divider_2/tspc_2/Z2 divider_2/tspc_2/Z3 0.16fF
C598 divider_2/nor_0/A divider_2/tspc_2/Z4 0.21fF
C599 ro_complete_0/a2 ro_complete_0/cbank_0/switch_2/vin 0.14fF
C600 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/a4 0.09fF
C601 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/a5 0.09fF
C602 divider_2/mc2 divider_2/nor_1/B 0.15fF
C603 divider_1/mc2 divider_1/and_0/OUT 0.05fF
C604 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Z4 0.36fF
C605 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/clk 0.11fF
C606 divider_2/nor_1/B divider_2/nor_1/Z1 0.06fF
C607 divider_0/tspc_2/Z3 divider_0/tspc_2/Z4 0.65fF
C608 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/OUT2 0.02fF
C609 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a3 0.13fF
C610 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/R 0.27fF
C611 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/nor_0/A 0.01fF
C612 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z4 0.12fF
C613 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/OUT4 1.11fF
C614 divider_1/tspc_1/Z2 divider_1/tspc_2/Q 0.14fF
C615 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/UP 0.21fF
C616 divider_2/tspc_1/Z3 divider_2/tspc_1/Z4 0.65fF
C617 pd_1/tspc_r_1/Qbar1 pd_1/UP 0.11fF
C618 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C619 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/clk 0.51fF
C620 divider_2/and_0/A divider_2/and_0/B 0.18fF
C621 divider_0/tspc_2/Q divider_0/tspc_1/Z1 0.01fF
C622 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z4 0.00fF
C623 ro_complete_1/a2 ro_complete_1/cbank_2/v 0.05fF
C624 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C625 divider_1/prescaler_0/tspc_0/Z3 divider_1/clk 0.64fF
C626 divider_0/prescaler_0/Out divider_0/tspc_2/Z2 0.11fF
C627 divider_0/tspc_0/Z3 divider_0/tspc_0/Z2 0.16fF
C628 divider_0/prescaler_0/tspc_1/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C629 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z3 0.16fF
C630 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C631 divider_2/nor_1/B divider_2/tspc_0/Z4 0.22fF
C632 divider_1/tspc_0/Z2 divider_1/tspc_0/Z1 1.07fF
C633 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/and_pd_0/Out1 0.05fF
C634 pll_full_0/divider_0/tspc_1/Z4 pll_full_0/divider_0/nor_0/A 0.02fF
C635 pd_0/R pd_0/and_pd_0/Z1 0.02fF
C636 pd_0/tspc_r_1/Qbar1 pd_0/tspc_r_1/z5 0.20fF
C637 divider_2/tspc_0/Z4 divider_2/tspc_0/Z2 0.36fF
C638 divider_1/nor_0/A divider_1/tspc_2/Z1 0.03fF
C639 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z3 0.05fF
C640 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/nor_0/B 0.18fF
C641 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z4 0.12fF
C642 divider_2/nor_0/B divider_2/tspc_2/a_630_n680# 0.01fF
C643 divider_2/prescaler_0/tspc_2/D divider_2/prescaler_0/nand_0/z1 0.24fF
C644 divider_2/prescaler_0/tspc_0/Z4 divider_2/clk 0.12fF
C645 pll_full_0/pd_0/REF pll_full_0/divbuf_1/OUT5 0.00fF
C646 pll_full_1/divider_0/prescaler_0/tspc_2/Q pll_full_1/divider_0/prescaler_0/nand_1/z1 0.01fF
C647 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/clk 0.11fF
C648 divider_0/tspc_0/Z3 divider_0/tspc_1/Q 0.45fF
C649 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/tspc_0/Z4 0.12fF
C650 ro_complete_1/cbank_1/switch_5/vin ro_complete_1/cbank_1/v 1.30fF
C651 pll_full_0/divbuf_1/OUT2 pll_full_0/divbuf_1/OUT3 1.37fF
C652 pll_full_0/ro_complete_0/cbank_1/switch_4/vin pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C653 divider_0/mc2 divider_0/and_0/A 0.16fF
C654 pll_full_0/ro_complete_0/cbank_1/switch_5/vin pll_full_0/divider_0/clk 1.46fF
C655 pll_full_1/pd_0/UP pll_full_1/pd_0/R 0.46fF
C656 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/nor_0/B 0.30fF
C657 io_analog[6] io_clamp_low[2] 0.53fF
C658 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/DOWN 0.21fF
C659 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.13fF
C660 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z3 0.38fF
C661 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z2 1.07fF
C662 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z4 0.12fF
C663 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Qbar1 0.38fF
C664 pd_1/DIV pd_1/tspc_r_0/Z3 0.65fF
C665 pd_0/and_pd_0/Out1 pd_0/and_pd_0/Z1 0.18fF
C666 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/nor_0/B 0.02fF
C667 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z4 0.15fF
C668 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.36fF
C669 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/tspc_r_0/z5 0.02fF
C670 divider_2/prescaler_0/tspc_2/D divider_2/clk 0.26fF
C671 pll_full_1/divider_0/tspc_2/Z3 pll_full_1/divider_0/tspc_2/Z4 0.65fF
C672 ro_complete_0/a0 ro_complete_0/cbank_2/switch_5/vin 0.09fF
C673 divider_0/Out divider_0/nor_1/B 0.22fF
C674 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z3 0.33fF
C675 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/tspc_0/Z4 0.12fF
C676 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/Out 0.11fF
C677 divider_0/and_0/OUT divider_0/and_0/B 0.01fF
C678 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/clk 0.51fF
C679 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/switch_3/vin 0.09fF
C680 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z1 0.09fF
C681 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_2/a_630_n680# 0.04fF
C682 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/tspc_1/Z4 0.12fF
C683 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C684 pd_0/DIV pd_0/R 0.51fF
C685 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/z5 0.20fF
C686 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z1 0.17fF
C687 divider_1/tspc_1/Z2 divider_1/nor_0/A 0.15fF
C688 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/D 0.03fF
C689 pd_1/tspc_r_0/Z4 pd_1/tspc_r_0/z5 0.04fF
C690 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C691 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/Z3 0.05fF
C692 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z2 0.16fF
C693 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.06fF
C694 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.16fF
C695 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/clk 0.14fF
C696 pll_full_1/divider_0/nor_1/Z1 pll_full_1/divider_0/and_0/B 0.78fF
C697 ro_complete_0/a4 ro_complete_0/a5 1.27fF
C698 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/a5 0.09fF
C699 ro_complete_0/cbank_0/switch_0/vin ro_complete_0/cbank_0/v 1.30fF
C700 divider_1/mc2 divider_1/nor_1/B 0.15fF
C701 ro_complete_1/a5 ro_complete_1/cbank_1/v 0.10fF
C702 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_0/vin 0.19fF
C703 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C704 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C705 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/a3 0.09fF
C706 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/nand_0/z1 0.07fF
C707 divider_0/prescaler_0/tspc_2/a_740_n680# divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C708 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_0/z5 0.02fF
C709 pll_full_1/pd_0/tspc_r_0/Qbar pll_full_1/pd_0/DOWN 0.21fF
C710 divider_1/tspc_0/Z4 divider_1/tspc_0/Z1 0.00fF
C711 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/Z4 0.36fF
C712 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/clk 0.11fF
C713 pll_full_1/divbuf_0/OUT2 pll_full_1/divbuf_0/a_492_n240# 0.42fF
C714 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/z5 0.03fF
C715 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/nand_0/z1 0.01fF
C716 pd_0/REF pd_0/tspc_r_1/Qbar1 0.12fF
C717 divider_1/tspc_1/Z4 divider_1/tspc_2/Q 0.15fF
C718 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.08fF
C719 pd_1/tspc_r_1/z5 pd_1/UP 0.03fF
C720 divider_2/prescaler_0/Out divider_2/nor_0/A 0.15fF
C721 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/D 0.05fF
C722 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a2 0.09fF
C723 ro_complete_1/a4 ro_complete_1/cbank_2/switch_1/vin 0.09fF
C724 divider_1/tspc_0/Z3 divider_1/nor_1/B 0.38fF
C725 divider_0/Out divider_0/tspc_0/a_630_n680# 0.04fF
C726 ro_complete_1/a0 ro_complete_1/cbank_1/switch_5/vin 0.09fF
C727 pll_full_0/ro_complete_0/cbank_0/switch_5/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C728 divider_0/prescaler_0/m1_2700_2190# divider_0/clk 0.01fF
C729 pll_full_0/pd_0/DIV pll_full_0/divider_0/clk 2.26fF
C730 divider_2/nor_1/B divider_2/tspc_0/a_630_n680# 0.35fF
C731 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/Out 0.11fF
C732 divider_1/tspc_1/Z1 divider_1/tspc_1/Z2 1.07fF
C733 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C734 pd_1/tspc_r_0/Qbar1 pd_1/DIV 0.12fF
C735 divider_2/tspc_0/Z2 divider_2/tspc_0/a_630_n680# 0.01fF
C736 divider_1/tspc_2/Z3 divider_1/tspc_2/Q 0.05fF
C737 divider_1/nor_0/A divider_1/and_0/A 0.01fF
C738 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z4 0.15fF
C739 pll_full_1/divbuf_0/IN pll_full_1/divider_0/nor_1/B 0.27fF
C740 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.28fF
C741 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/UP 0.03fF
C742 divider_2/nor_0/B divider_2/tspc_2/Q 0.22fF
C743 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/and_0/B 0.01fF
C744 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_1/Z4 0.02fF
C745 pll_full_0/pd_0/REF pll_full_0/pd_0/R 0.61fF
C746 ro_complete_1/cbank_2/switch_4/vin ro_complete_1/cbank_2/v 1.30fF
C747 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z2 0.16fF
C748 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/clk 0.14fF
C749 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/and_0/B 0.78fF
C750 divider_0/prescaler_0/tspc_0/D divider_0/prescaler_0/nand_1/z1 0.21fF
C751 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Z4 0.65fF
C752 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/switch_1/vin 0.19fF
C753 pd_1/R pd_1/UP 0.45fF
C754 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/z5 0.11fF
C755 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/z5 0.11fF
C756 divider_2/prescaler_0/tspc_0/Z1 divider_2/prescaler_0/tspc_0/D 0.03fF
C757 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.91fF
C758 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# 0.19fF
C759 divider_2/tspc_2/Z2 divider_2/tspc_2/Z4 0.36fF
C760 ro_complete_0/cbank_1/v ro_complete_0/cbank_2/v 1.36fF
C761 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_1/Q 0.13fF
C762 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.15fF
C763 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/D 0.05fF
C764 divider_1/tspc_1/Z4 divider_1/nor_0/A 0.02fF
C765 divider_1/tspc_1/Z3 divider_1/tspc_1/a_630_n680# 0.05fF
C766 pd_0/tspc_r_0/Z4 pd_0/tspc_r_0/z5 0.04fF
C767 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_1/Q 0.21fF
C768 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z3 0.06fF
C769 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/switch_0/vin 0.19fF
C770 divider_0/tspc_2/Q divider_0/tspc_1/Z3 0.45fF
C771 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/tspc_0/Z4 0.65fF
C772 ro_complete_1/cbank_1/switch_2/vin ro_complete_1/cbank_1/v 1.30fF
C773 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C774 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C775 pll_full_0/pd_0/REF pll_full_0/pd_0/DOWN 1.48fF
C776 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/Out 0.21fF
C777 divider_0/prescaler_0/tspc_2/Z2 divider_0/prescaler_0/tspc_2/Z4 0.36fF
C778 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z1 0.01fF
C779 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C780 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/B 0.01fF
C781 divider_2/tspc_0/Z4 divider_2/tspc_0/a_630_n680# 0.12fF
C782 divider_1/nor_0/A divider_1/tspc_2/Z3 0.38fF
C783 divider_1/tspc_2/Z1 divider_1/tspc_2/Z2 1.07fF
C784 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z4 0.12fF
C785 pd_1/R pd_1/tspc_r_1/Z3 0.29fF
C786 pd_1/tspc_r_0/Z2 pd_1/DIV 0.19fF
C787 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.01fF
C788 divider_2/and_0/OUT divider_2/prescaler_0/tspc_2/Q 0.04fF
C789 divider_2/prescaler_0/tspc_1/Z3 divider_2/clk 0.45fF
C790 divider_2/nor_0/B divider_2/nor_0/A 1.21fF
C791 pll_full_1/divider_0/prescaler_0/tspc_0/D pll_full_1/divider_0/prescaler_0/nand_1/z1 0.21fF
C792 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/v 1.43fF
C793 ro_complete_0/cbank_1/switch_2/vin ro_complete_0/cbank_1/v 1.30fF
C794 divider_0/tspc_0/Z3 divider_0/tspc_0/Z4 0.65fF
C795 ro_complete_1/cbank_0/v ro_complete_1/cbank_2/v 0.04fF
C796 pll_full_0/divbuf_1/OUT3 pll_full_0/divbuf_1/OUT4 5.16fF
C797 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C798 divider_1/nor_1/B divider_1/tspc_0/Z2 0.40fF
C799 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C800 divider_1/tspc_1/Z1 divider_1/tspc_1/Z4 0.00fF
C801 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/prescaler_0/tspc_2/Z2 0.01fF
C802 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z3 0.16fF
C803 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z4 0.21fF
C804 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_0/Z3 0.27fF
C805 divider_1/and_0/out1 divider_1/and_0/Z1 0.36fF
C806 pd_1/R pd_1/and_pd_0/Out1 0.33fF
C807 pd_1/REF pd_1/tspc_r_1/Z1 0.17fF
C808 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/z5 0.20fF
C809 pd_0/tspc_r_1/z5 pd_0/UP 0.03fF
C810 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.15fF
C811 pll_full_1/ro_complete_0/a0 pll_full_1/divider_0/clk 0.11fF
C812 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/a_630_n680# 0.19fF
C813 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/switch_4/vin 0.20fF
C814 ro_complete_1/cbank_1/switch_3/vin ro_complete_1/cbank_1/switch_4/vin 0.20fF
C815 ro_complete_0/a0 ro_complete_0/cbank_2/v 0.05fF
C816 divider_1/tspc_0/Z3 divider_1/tspc_0/Z2 0.16fF
C817 divider_0/tspc_1/Z1 divider_0/nor_0/B 0.03fF
C818 divider_0/tspc_1/Z3 divider_0/tspc_1/a_630_n680# 0.05fF
C819 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Z4 0.08fF
C820 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z3 0.05fF
C821 pll_full_0/ro_complete_0/cbank_2/switch_2/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C822 pll_full_1/ro_complete_0/a2 pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.14fF
C823 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/a4 0.09fF
C824 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/a5 0.09fF
C825 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/A 0.55fF
C826 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_1/Z4 0.21fF
C827 pd_0/tspc_r_0/Qbar1 pd_0/R 0.01fF
C828 pd_0/DOWN pd_0/tspc_r_0/Qbar 0.21fF
C829 pd_0/DIV pd_0/tspc_r_0/Z4 0.02fF
C830 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z3 0.65fF
C831 divider_2/tspc_0/Z3 divider_2/tspc_0/Z1 0.06fF
C832 divider_1/and_0/OUT divider_1/prescaler_0/nand_0/z1 0.01fF
C833 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/z5 0.11fF
C834 divider_2/tspc_1/Z1 divider_2/nor_0/B 0.03fF
C835 pd_1/tspc_r_0/Z4 pd_1/tspc_r_1/Z4 0.02fF
C836 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/a1 0.14fF
C837 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.36fF
C838 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/a1 0.14fF
C839 divider_1/tspc_1/Q divider_1/tspc_1/Z3 0.05fF
C840 divider_0/prescaler_0/m1_2700_2190# divider_0/prescaler_0/tspc_1/Q 0.38fF
C841 divider_0/prescaler_0/tspc_0/Z4 divider_0/prescaler_0/tspc_0/D 0.11fF
C842 divider_0/and_0/out1 divider_0/and_0/A 0.01fF
C843 divider_0/tspc_0/Z1 divider_0/tspc_0/Z2 1.07fF
C844 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/Z2 0.25fF
C845 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/prescaler_0/nand_0/z1 0.24fF
C846 divider_2/nor_1/B divider_2/tspc_1/a_630_n680# 0.00fF
C847 divider_2/nor_0/Z1 divider_2/and_0/A 0.80fF
C848 divider_1/and_0/OUT divider_1/clk 0.04fF
C849 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_0/Z2 0.01fF
C850 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/z5 0.04fF
C851 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/Z3 0.03fF
C852 divider_2/prescaler_0/Out divider_2/tspc_2/Z2 0.11fF
C853 divider_2/prescaler_0/tspc_2/Z4 divider_2/prescaler_0/tspc_2/D 0.11fF
C854 ro_complete_0/a4 ro_complete_0/cbank_2/switch_0/vin 0.12fF
C855 ro_complete_1/a0 ro_complete_1/cbank_1/v 0.05fF
C856 ro_complete_1/a3 ro_complete_1/cbank_2/v 0.05fF
C857 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C858 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z1 0.17fF
C859 divider_1/nor_1/B divider_1/tspc_0/Z4 0.22fF
C860 divider_0/tspc_1/Q divider_0/tspc_0/Z1 0.01fF
C861 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/clk 0.01fF
C862 pll_full_0/ro_complete_0/a0 pll_full_0/divider_0/clk 0.11fF
C863 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.01fF
C864 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C865 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/clk 0.01fF
C866 divider_1/tspc_1/Z2 divider_1/tspc_1/Z3 0.16fF
C867 pll_full_1/divbuf_0/OUT5 pll_full_1/divbuf_0/IN 0.00fF
C868 pd_1/DOWN pd_1/tspc_r_0/Z3 0.03fF
C869 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z3 0.16fF
C870 pll_full_1/ro_complete_0/a3 pll_full_1/divider_0/clk 0.11fF
C871 divider_2/prescaler_0/tspc_2/Z3 divider_2/clk 0.45fF
C872 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/switch_5/vin 0.20fF
C873 ro_complete_0/a3 ro_complete_0/cbank_2/v 0.05fF
C874 divider_1/tspc_0/Z3 divider_1/tspc_0/Z4 0.65fF
C875 pll_full_0/ro_complete_0/a1 pll_full_0/ro_complete_0/cbank_2/v 0.05fF
C876 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_1/a_630_n680# 0.19fF
C877 divider_0/prescaler_0/tspc_1/Q divider_0/nor_0/A 0.03fF
C878 divider_0/nor_1/B divider_0/tspc_0/Z2 0.40fF
C879 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Qbar1 0.12fF
C880 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/DOWN 0.03fF
C881 divider_1/prescaler_0/Out divider_1/tspc_2/a_630_n680# 0.01fF
C882 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/D 0.15fF
C883 divider_1/prescaler_0/tspc_0/Z2 divider_1/clk 0.11fF
C884 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.09fF
C885 pd_1/DOWN pd_1/and_pd_0/Z1 0.07fF
C886 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Z4 0.65fF
C887 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.09fF
C888 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Q 0.04fF
C889 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/A 0.01fF
C890 pll_full_1/divider_0/tspc_0/Z1 pll_full_1/divider_0/tspc_0/Z2 1.07fF
C891 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Qbar1 0.12fF
C892 divider_0/mc2 divider_0/prescaler_0/tspc_2/a_630_n680# 0.33fF
C893 divider_0/tspc_1/Z2 divider_0/tspc_1/Z4 0.36fF
C894 divider_0/tspc_1/Q divider_0/nor_1/B 0.22fF
C895 divider_0/prescaler_0/tspc_0/Z2 divider_0/clk 0.11fF
C896 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z2 0.71fF
C897 divider_1/prescaler_0/tspc_1/Z1 divider_1/prescaler_0/Out 0.08fF
C898 pll_full_1/ro_complete_0/cbank_0/switch_0/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C899 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.05fF
C900 pd_0/R pd_0/REF 0.61fF
C901 pll_full_1/divbuf_0/IN pll_full_1/divider_0/tspc_0/a_630_n680# 0.04fF
C902 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z4 0.00fF
C903 divider_2/prescaler_0/tspc_1/Z2 divider_2/clk 0.11fF
C904 divider_2/prescaler_0/tspc_1/Z3 divider_2/prescaler_0/tspc_1/Q 0.21fF
C905 divider_2/and_0/B divider_2/and_0/Z1 0.07fF
C906 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/a1 0.14fF
C907 ro_complete_0/a3 ro_complete_0/cbank_1/switch_2/vin 0.09fF
C908 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/switch_5/vin 0.20fF
C909 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/UP 0.03fF
C910 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/a0 0.13fF
C911 pll_full_0/ro_complete_0/a3 pll_full_0/divider_0/clk 0.11fF
C912 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z2 0.01fF
C913 pll_full_1/pd_0/UP pll_full_1/pd_0/DOWN 4.58fF
C914 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/tspc_1/Z3 0.45fF
C915 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C916 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C917 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_1/a_630_n680# 0.19fF
C918 divider_1/prescaler_0/tspc_1/Z2 divider_1/and_0/OUT 0.06fF
C919 cp_0/a_1710_0# cp_0/out 0.84fF
C920 pd_1/R pd_1/DIV 0.51fF
C921 pd_1/tspc_r_0/Qbar1 pd_1/DOWN 0.11fF
C922 divider_1/tspc_2/Z2 divider_1/tspc_2/Z3 0.16fF
C923 divider_1/nor_0/A divider_1/tspc_2/Z4 0.21fF
C924 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z2 1.07fF
C925 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/m1_2700_2190# 0.11fF
C926 divider_2/prescaler_0/tspc_1/Z4 divider_2/clk 0.12fF
C927 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/nor_0/A 0.03fF
C928 pll_full_1/divider_0/nor_1/B pll_full_1/divider_0/tspc_0/Z2 0.40fF
C929 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/switch_5/vin 0.20fF
C930 divider_0/tspc_0/a_630_n680# divider_0/tspc_1/Q 0.01fF
C931 pll_full_1/pd_0/tspc_r_1/Z1 pll_full_1/pd_0/tspc_r_1/Z3 0.09fF
C932 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/DIV 0.02fF
C933 divider_1/nor_1/B divider_1/tspc_0/a_630_n680# 0.35fF
C934 pll_full_1/pd_0/REF pll_full_1/pd_0/R 0.61fF
C935 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C936 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/Out 0.05fF
C937 divider_1/tspc_1/Z3 divider_1/tspc_1/Z4 0.65fF
C938 io_analog[5] io_clamp_high[1] 0.53fF
C939 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/A 0.01fF
C940 pll_full_1/divbuf_0/a_492_n240# pll_full_1/divbuf_0/IN 0.13fF
C941 pll_full_0/divider_0/tspc_2/Z2 pll_full_0/divider_0/tspc_2/Z4 0.36fF
C942 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z2 0.25fF
C943 divider_1/and_0/A divider_1/and_0/B 0.18fF
C944 pll_full_0/pd_0/tspc_r_0/Z3 pll_full_0/pd_0/tspc_r_0/z5 0.11fF
C945 divider_2/tspc_2/a_630_n680# divider_2/nor_0/A 0.35fF
C946 divider_2/prescaler_0/tspc_1/Q divider_2/clk 0.60fF
C947 divider_1/tspc_0/Z3 divider_1/tspc_0/a_630_n680# 0.05fF
C948 divider_0/tspc_1/Z3 divider_0/nor_0/B 0.38fF
C949 divider_0/tspc_1/Q divider_0/tspc_1/a_630_n680# 0.04fF
C950 divider_0/prescaler_0/tspc_1/Z1 divider_0/prescaler_0/tspc_1/Z2 1.07fF
C951 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z4 0.12fF
C952 ro_complete_1/cbank_2/switch_5/vin ro_complete_1/cbank_2/v 1.30fF
C953 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C954 pll_full_0/pd_0/tspc_r_0/Qbar pll_full_0/pd_0/tspc_r_0/Qbar1 0.01fF
C955 divider_1/tspc_0/Z4 divider_1/tspc_0/Z2 0.36fF
C956 divider_0/nor_0/A divider_0/tspc_2/Z1 0.03fF
C957 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z3 0.05fF
C958 pll_full_1/pd_0/DIV pll_full_1/pd_0/R 0.51fF
C959 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C960 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C961 divider_1/nor_0/B divider_1/tspc_2/a_630_n680# 0.01fF
C962 divider_1/prescaler_0/tspc_2/D divider_1/prescaler_0/nand_0/z1 0.24fF
C963 divider_1/prescaler_0/tspc_0/Z4 divider_1/clk 0.12fF
C964 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/z5 0.11fF
C965 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/nor_0/B 0.06fF
C966 pd_1/tspc_r_0/z5 pd_1/tspc_r_1/z5 0.02fF
C967 divider_2/tspc_1/Z3 divider_2/nor_0/B 0.38fF
C968 divider_2/prescaler_0/tspc_0/Z2 divider_2/prescaler_0/tspc_0/D 0.09fF
C969 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/A 0.15fF
C970 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z3 0.45fF
C971 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/a1 0.14fF
C972 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/v 1.30fF
C973 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/a3 0.09fF
C974 pll_full_0/pd_0/and_pd_0/Out1 pll_full_0/pd_0/UP 0.33fF
C975 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT3 0.26fF
C976 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C977 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C978 divider_1/tspc_1/Q divider_1/tspc_0/Z1 0.01fF
C979 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Q 0.04fF
C980 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_0/divider_0/prescaler_0/Out 0.21fF
C981 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT3 0.26fF
C982 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/tspc_r_1/Qbar1 0.01fF
C983 pll_full_0/divider_0/nor_1/B pll_full_0/divider_0/tspc_0/Z2 0.40fF
C984 pll_full_0/pd_0/DIV pll_full_0/pd_0/R 0.51fF
C985 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z1 0.71fF
C986 pll_full_1/pd_0/tspc_r_0/Qbar1 pll_full_1/pd_0/R 0.01fF
C987 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.04fF
C988 pll_full_1/ro_complete_0/cbank_1/switch_1/vin pll_full_1/ro_complete_0/cbank_1/switch_0/vin 0.19fF
C989 divider_1/prescaler_0/tspc_2/D divider_1/clk 0.26fF
C990 pd_1/tspc_r_0/Qbar pd_1/tspc_r_0/Qbar1 0.01fF
C991 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Z1 0.09fF
C992 pd_0/REF pd_0/tspc_r_1/Z2 0.19fF
C993 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_1/divider_0/prescaler_0/Out 0.04fF
C994 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/cbank_1/v 1.30fF
C995 ro_complete_0/cbank_0/switch_5/vin ro_complete_0/cbank_0/v 1.30fF
C996 pll_full_0/pd_0/and_pd_0/Z1 pll_full_0/pd_0/UP 0.06fF
C997 divider_0/nor_0/Z1 divider_0/and_0/A 0.80fF
C998 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C999 divider_0/tspc_0/Z4 divider_0/tspc_0/Z1 0.00fF
C1000 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/D 0.03fF
C1001 pll_full_0/divider_0/tspc_2/Q pll_full_0/divider_0/nor_0/B 0.22fF
C1002 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/nor_1/B 0.38fF
C1003 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1004 pll_full_1/pd_0/R pll_full_1/pd_0/and_pd_0/Out1 0.33fF
C1005 pll_full_0/pd_0/R pll_full_0/pd_0/DOWN 0.36fF
C1006 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Z4 0.36fF
C1007 pd_0/tspc_r_1/Qbar1 pd_0/UP 0.11fF
C1008 pll_full_1/divider_0/nor_0/Z1 pll_full_1/divider_0/and_0/B 0.18fF
C1009 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C1010 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1011 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z3 0.33fF
C1012 divider_2/nor_0/B divider_2/and_0/B 0.31fF
C1013 divider_2/prescaler_0/tspc_2/Z4 divider_2/clk 0.12fF
C1014 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z1 0.03fF
C1015 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z3 0.05fF
C1016 ro_complete_1/cbank_0/switch_4/vin ro_complete_1/cbank_0/v 1.30fF
C1017 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/z5 0.04fF
C1018 divider_1/prescaler_0/tspc_0/a_630_n680# divider_1/prescaler_0/Out 0.04fF
C1019 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_1/Q 0.06fF
C1020 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/UP 0.06fF
C1021 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z1 0.17fF
C1022 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1023 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/and_0/OUT 0.14fF
C1024 divider_2/mc2 divider_2/and_0/A 0.16fF
C1025 divider_1/prescaler_0/Out divider_1/nor_0/A 0.15fF
C1026 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/D 0.05fF
C1027 pd_0/DIV pd_0/tspc_r_0/Z3 0.65fF
C1028 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1029 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/tspc_1/Q 0.06fF
C1030 divider_2/nor_0/A divider_2/tspc_2/Q 0.55fF
C1031 pll_full_0/ro_complete_0/a4 pll_full_0/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1032 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z3 0.65fF
C1033 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/D 0.05fF
C1034 divider_0/tspc_0/Z4 divider_0/nor_1/B 0.22fF
C1035 divider_1/tspc_0/Z2 divider_1/tspc_0/a_630_n680# 0.01fF
C1036 divider_0/nor_0/A divider_0/and_0/A 0.01fF
C1037 pll_full_1/pd_0/tspc_r_1/Qbar pll_full_1/pd_0/R 0.03fF
C1038 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.11fF
C1039 divider_1/nor_0/B divider_1/tspc_2/Q 0.22fF
C1040 pd_0/DOWN pd_0/tspc_r_1/Qbar 0.02fF
C1041 pd_0/R pd_0/tspc_r_1/Qbar1 0.30fF
C1042 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# 0.19fF
C1043 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Z4 0.65fF
C1044 divider_2/prescaler_0/tspc_0/Z4 divider_2/prescaler_0/tspc_0/D 0.11fF
C1045 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/D 0.03fF
C1046 ro_complete_0/a3 ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1047 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1048 ro_complete_1/cbank_1/switch_4/vin ro_complete_1/cbank_1/v 1.30fF
C1049 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1050 pll_full_0/divider_0/nor_0/Z1 pll_full_0/divider_0/and_0/B 0.18fF
C1051 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z4 0.02fF
C1052 divider_2/tspc_1/Q divider_2/tspc_1/Z3 0.05fF
C1053 divider_1/prescaler_0/m1_2700_2190# divider_1/nor_0/A 0.01fF
C1054 divider_1/nor_1/B divider_1/tspc_1/a_630_n680# 0.00fF
C1055 divider_1/prescaler_0/tspc_0/Z1 divider_1/prescaler_0/tspc_0/D 0.03fF
C1056 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.12fF
C1057 divider_1/tspc_2/Z2 divider_1/tspc_2/Z4 0.36fF
C1058 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/tspc_1/Z3 0.16fF
C1059 pll_full_1/ro_complete_0/a4 pll_full_1/divider_0/clk 0.01fF
C1060 divider_2/tspc_1/Z1 divider_2/tspc_2/Q 0.01fF
C1061 ro_complete_1/a2 ro_complete_1/cbank_1/switch_3/vin 0.09fF
C1062 ro_complete_0/a4 ro_complete_0/cbank_2/v 0.05fF
C1063 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/cbank_1/v 1.30fF
C1064 divider_0/tspc_2/Q divider_0/tspc_1/Z4 0.15fF
C1065 divider_0/tspc_0/a_630_n680# divider_0/tspc_0/Z4 0.12fF
C1066 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_2/v 0.08fF
C1067 pll_full_0/ro_complete_0/a0 pll_full_0/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1068 pll_full_0/pd_0/REF pll_full_0/pd_0/tspc_r_1/Z2 0.19fF
C1069 divider_2/nor_1/B divider_2/tspc_0/Z3 0.38fF
C1070 divider_0/tspc_1/Z4 divider_0/nor_0/A 0.02fF
C1071 divider_0/nor_0/B divider_0/tspc_0/Z2 0.20fF
C1072 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1073 io_analog[4] io_clamp_low[0] 0.53fF
C1074 divider_2/tspc_0/Z3 divider_2/tspc_0/Z2 0.16fF
C1075 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1076 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z3 0.06fF
C1077 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1078 cp_0/out cp_0/a_1710_n2840# 0.61fF
C1079 pll_full_1/divider_0/tspc_1/Z1 pll_full_1/divider_0/tspc_1/Z4 0.00fF
C1080 divider_2/and_0/OUT divider_2/and_0/Z1 0.04fF
C1081 divider_2/tspc_2/a_630_n680# divider_2/tspc_2/Z2 0.01fF
C1082 divider_2/prescaler_0/tspc_2/Q divider_2/clk 0.05fF
C1083 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_4/vin 0.20fF
C1084 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/and_0/A 0.01fF
C1085 divider_0/prescaler_0/tspc_0/Z1 divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1086 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/cbank_0/v 1.30fF
C1087 ro_complete_0/cbank_2/switch_2/vin ro_complete_0/cbank_2/v 1.30fF
C1088 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT4 5.16fF
C1089 pll_full_0/ro_complete_0/cbank_0/switch_1/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1090 divider_0/tspc_2/Q divider_0/tspc_2/Z3 0.05fF
C1091 divider_0/tspc_1/Q divider_0/nor_0/B 0.51fF
C1092 pll_full_1/pd_0/UP pll_full_1/pd_0/tspc_r_1/Z3 0.03fF
C1093 pll_full_0/ro_complete_0/cbank_2/switch_4/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1094 divider_1/tspc_0/Z4 divider_1/tspc_0/a_630_n680# 0.12fF
C1095 divider_0/nor_0/A divider_0/tspc_2/Z3 0.38fF
C1096 divider_0/tspc_2/Z1 divider_0/tspc_2/Z2 1.07fF
C1097 divider_0/tspc_2/a_630_n680# divider_0/tspc_2/Z4 0.12fF
C1098 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/nor_0/A 0.15fF
C1099 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1100 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1101 pd_0/tspc_r_0/Z2 pd_0/R 0.21fF
C1102 pd_0/DOWN pd_0/tspc_r_0/z5 0.03fF
C1103 divider_2/prescaler_0/m1_2700_2190# divider_2/nor_0/A 0.01fF
C1104 divider_1/and_0/OUT divider_1/prescaler_0/tspc_2/Q 0.04fF
C1105 divider_1/prescaler_0/tspc_1/Z3 divider_1/clk 0.45fF
C1106 divider_1/nor_0/B divider_1/nor_0/A 1.21fF
C1107 pd_1/tspc_r_1/Z3 pd_1/UP 0.03fF
C1108 pd_1/tspc_r_1/Z4 pd_1/tspc_r_1/z5 0.04fF
C1109 ro_complete_0/cbank_1/switch_1/vin ro_complete_0/a3 0.14fF
C1110 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/nor_0/A 0.01fF
C1111 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1112 pll_full_1/divider_0/tspc_0/a_630_n680# pll_full_1/divider_0/tspc_0/Z2 0.01fF
C1113 divider_2/and_0/out1 divider_2/and_0/B 0.18fF
C1114 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/a1 0.14fF
C1115 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/a_630_n680# 0.01fF
C1116 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT4 1.11fF
C1117 divider_0/tspc_1/a_630_n680# divider_0/tspc_1/Z4 0.12fF
C1118 divider_0/prescaler_0/tspc_2/a_630_n680# divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1119 pll_full_0/ro_complete_0/a4 pll_full_0/divider_0/clk 0.01fF
C1120 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT4 1.11fF
C1121 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/R 0.30fF
C1122 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/tspc_r_0/Z3 0.25fF
C1123 divider_1/nor_0/Z1 divider_1/and_0/A 0.80fF
C1124 divider_0/and_0/out1 divider_0/and_0/Z1 0.36fF
C1125 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.09fF
C1126 pd_1/R pd_1/DOWN 0.36fF
C1127 pd_0/DOWN pd_0/and_pd_0/Z1 0.07fF
C1128 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1129 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 0.06fF
C1130 pd_1/and_pd_0/Out1 pd_1/UP 0.33fF
C1131 divider_2/prescaler_0/tspc_2/Z3 divider_2/prescaler_0/tspc_2/Q 0.05fF
C1132 ro_complete_0/cbank_1/switch_4/vin ro_complete_0/a0 0.13fF
C1133 pll_full_1/divider_0/tspc_1/Z4 pll_full_1/divider_0/nor_0/A 0.02fF
C1134 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_0/Z2 0.20fF
C1135 ro_complete_1/cbank_0/switch_0/vin ro_complete_1/cbank_0/v 1.30fF
C1136 ro_complete_0/a5 ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1137 divider_1/tspc_1/Q divider_1/nor_1/B 0.22fF
C1138 ro_complete_1/a1 ro_complete_1/cbank_2/v 0.05fF
C1139 divider_0/mc2 divider_0/and_0/out1 0.06fF
C1140 divider_0/and_0/OUT divider_0/prescaler_0/nand_0/z1 0.01fF
C1141 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/and_0/A 0.01fF
C1142 divider_2/tspc_0/Z3 divider_2/tspc_0/Z4 0.65fF
C1143 divider_1/tspc_1/Z1 divider_1/nor_0/B 0.03fF
C1144 pll_full_1/divbuf_1/OUT2 pll_full_1/divbuf_1/OUT3 1.37fF
C1145 pll_full_1/ro_complete_0/cbank_1/switch_4/vin pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.20fF
C1146 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/nor_0/A 0.35fF
C1147 cp_0/a_1710_0# cp_0/a_1710_n2840# 0.83fF
C1148 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/Z3 0.38fF
C1149 pll_full_1/divider_0/tspc_1/Z2 pll_full_1/divider_0/nor_0/B 0.30fF
C1150 pll_full_1/ro_complete_0/a1 pll_full_1/divider_0/clk 0.11fF
C1151 pll_full_0/pd_0/DOWN pll_full_0/pd_0/tspc_r_0/z5 0.03fF
C1152 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z3 0.38fF
C1153 pll_full_1/divider_0/tspc_2/Z1 pll_full_1/divider_0/tspc_2/Z2 1.07fF
C1154 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/tspc_2/Z4 0.12fF
C1155 divider_1/tspc_0/Z3 divider_1/tspc_1/Q 0.45fF
C1156 ro_complete_1/cbank_0/switch_1/vin ro_complete_1/a3 0.13fF
C1157 ro_complete_0/a1 ro_complete_0/cbank_2/v 0.05fF
C1158 io_clamp_low[2] io_clamp_high[2] 0.53fF
C1159 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z3 0.11fF
C1160 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/Z2 0.14fF
C1161 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/ro_complete_0/cbank_2/v 0.04fF
C1162 divider_0/and_0/OUT divider_0/clk 0.04fF
C1163 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/tspc_0/Z2 0.01fF
C1164 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1165 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_2/D 0.16fF
C1166 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.03fF
C1167 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Qbar1 0.38fF
C1168 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/R 0.03fF
C1169 divider_1/prescaler_0/Out divider_1/tspc_2/Z2 0.11fF
C1170 divider_1/prescaler_0/tspc_2/Z4 divider_1/prescaler_0/tspc_2/D 0.11fF
C1171 cp_0/a_1710_0# cp_0/down 0.32fF
C1172 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_2/a_630_n680# 0.04fF
C1173 pll_full_1/divider_0/tspc_1/a_630_n680# pll_full_1/divider_0/tspc_1/Z4 0.12fF
C1174 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_1/divider_0/prescaler_0/tspc_2/Z2 0.01fF
C1175 pll_full_0/cp_0/upbar pll_full_0/cp_0/down 0.02fF
C1176 pll_full_1/divider_0/and_0/out1 pll_full_1/divider_0/and_0/Z1 0.36fF
C1177 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/cbank_2/v 1.30fF
C1178 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT2 0.06fF
C1179 pll_full_0/divbuf_1/OUT5 pll_full_0/divbuf_1/OUT3 0.01fF
C1180 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1181 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/a_630_n680# 0.05fF
C1182 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_0/Z2 0.20fF
C1183 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z3 0.16fF
C1184 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/Z2 0.19fF
C1185 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1186 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1187 pll_full_1/ro_complete_0/cbank_0/switch_2/vin pll_full_1/ro_complete_0/a3 0.09fF
C1188 divider_1/prescaler_0/tspc_2/Z3 divider_1/clk 0.45fF
C1189 pll_full_0/pd_0/DOWN pll_full_0/cp_0/a_1710_0# 0.04fF
C1190 pll_full_1/divider_0/tspc_1/Q pll_full_1/divider_0/tspc_0/Z2 0.14fF
C1191 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/nand_0/z1 0.01fF
C1192 ro_complete_0/a2 ro_complete_0/cbank_1/v 0.05fF
C1193 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/a0 0.13fF
C1194 pll_full_1/pd_0/tspc_r_1/Z4 pll_full_1/pd_0/tspc_r_1/Z3 0.20fF
C1195 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/REF 0.04fF
C1196 pll_full_0/ro_complete_0/a1 pll_full_0/divider_0/clk 0.11fF
C1197 divider_2/tspc_1/Q divider_2/tspc_0/Z1 0.01fF
C1198 divider_1/mc2 divider_1/and_0/A 0.16fF
C1199 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/D 0.15fF
C1200 divider_0/prescaler_0/Out divider_0/clk 0.51fF
C1201 pll_full_1/pd_0/REF pll_full_1/pd_0/DOWN 1.48fF
C1202 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Z4 0.65fF
C1203 pll_full_1/ro_complete_0/cbank_0/switch_5/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1204 pd_0/R pd_0/UP 0.45fF
C1205 pd_0/tspc_r_1/Z4 pd_0/tspc_r_1/z5 0.04fF
C1206 pll_full_0/pd_0/tspc_r_1/Qbar pll_full_0/pd_0/DOWN 0.02fF
C1207 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Q 0.04fF
C1208 divider_2/tspc_1/Z3 divider_2/tspc_2/Q 0.45fF
C1209 divider_2/tspc_1/Z2 divider_2/tspc_1/a_630_n680# 0.01fF
C1210 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_2/Q 0.19fF
C1211 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/clk 0.01fF
C1212 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/clk 0.06fF
C1213 ro_complete_1/cbank_2/switch_3/vin ro_complete_1/a1 0.14fF
C1214 ro_complete_0/cbank_1/switch_0/vin ro_complete_0/cbank_1/v 1.43fF
C1215 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/a_492_n240# 0.00fF
C1216 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/Out 0.05fF
C1217 divider_0/nor_0/B divider_0/and_0/A 0.26fF
C1218 pll_full_0/divider_0/and_0/out1 pll_full_0/divider_0/and_0/Z1 0.36fF
C1219 divider_2/tspc_0/Z3 divider_2/tspc_0/a_630_n680# 0.05fF
C1220 divider_2/nor_0/Z1 divider_2/nor_0/B 0.06fF
C1221 divider_1/prescaler_0/tspc_2/Z1 divider_1/prescaler_0/tspc_2/Z4 0.00fF
C1222 divider_1/prescaler_0/tspc_1/Z2 divider_1/clk 0.11fF
C1223 divider_1/prescaler_0/tspc_1/Z3 divider_1/prescaler_0/tspc_1/Q 0.21fF
C1224 pd_0/and_pd_0/Out1 pd_0/UP 0.33fF
C1225 divider_1/and_0/B divider_1/and_0/Z1 0.07fF
C1226 pll_full_1/divider_0/tspc_1/Z3 pll_full_1/divider_0/tspc_1/Z4 0.65fF
C1227 divider_2/nor_0/A divider_2/tspc_2/Z2 0.23fF
C1228 divider_2/prescaler_0/tspc_0/D divider_2/clk 0.29fF
C1229 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1230 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1231 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT5 0.01fF
C1232 divider_1/tspc_1/Q divider_1/tspc_0/Z2 0.14fF
C1233 divider_0/tspc_0/Z4 divider_0/nor_0/B 0.02fF
C1234 pll_full_0/ro_complete_0/cbank_2/switch_0/vin pll_full_0/ro_complete_0/cbank_2/v 1.45fF
C1235 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_0/Z2 0.14fF
C1236 divider_0/tspc_2/Z2 divider_0/tspc_2/Z3 0.16fF
C1237 divider_0/nor_0/A divider_0/tspc_2/Z4 0.21fF
C1238 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_0/Qbar1 0.11fF
C1239 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/tspc_2/Z2 0.11fF
C1240 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.65fF
C1241 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT2 0.02fF
C1242 divider_1/prescaler_0/tspc_1/Z4 divider_1/clk 0.12fF
C1243 pd_0/tspc_r_0/Z2 pd_0/tspc_r_0/Z4 0.14fF
C1244 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z3 0.33fF
C1245 pd_1/tspc_r_1/Qbar pd_1/and_pd_0/Z1 0.02fF
C1246 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.15fF
C1247 ro_complete_0/a4 ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1248 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/v 1.30fF
C1249 ro_complete_1/cbank_2/switch_1/vin ro_complete_1/cbank_2/switch_2/vin 0.20fF
C1250 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT5 43.38fF
C1251 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1252 pll_full_0/ro_complete_0/cbank_0/switch_2/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1253 divider_0/nor_0/B divider_0/tspc_1/Z4 0.21fF
C1254 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_1/Q 0.45fF
C1255 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.05fF
C1256 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT5 43.38fF
C1257 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/clk 0.06fF
C1258 divider_2/mc2 divider_2/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1259 divider_0/and_0/A divider_0/and_0/B 0.18fF
C1260 pll_full_1/ro_complete_0/a3 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.13fF
C1261 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1262 pll_full_1/pd_0/DOWN pll_full_1/pd_0/and_pd_0/Out1 0.12fF
C1263 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z3 0.29fF
C1264 divider_1/tspc_2/a_630_n680# divider_1/nor_0/A 0.35fF
C1265 divider_1/prescaler_0/tspc_1/Q divider_1/clk 0.60fF
C1266 pd_0/R pd_0/and_pd_0/Out1 0.33fF
C1267 pd_0/REF pd_0/tspc_r_1/Z4 0.02fF
C1268 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z1 0.01fF
C1269 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.00fF
C1270 filter_0/v filter_0/a_4216_n2998# 0.36fF
C1271 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/and_0/A 0.26fF
C1272 ro_complete_0/cbank_2/switch_1/vin ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1273 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/Out 0.21fF
C1274 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/R 0.21fF
C1275 divider_0/prescaler_0/tspc_2/D divider_0/prescaler_0/nand_0/z1 0.24fF
C1276 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.33fF
C1277 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/a_492_n240# 0.01fF
C1278 divider_1/tspc_1/Z3 divider_1/nor_0/B 0.38fF
C1279 divider_1/prescaler_0/tspc_0/Z2 divider_1/prescaler_0/tspc_0/D 0.09fF
C1280 pll_full_1/divbuf_1/OUT3 pll_full_1/divbuf_1/OUT4 5.16fF
C1281 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1282 pll_full_0/divider_0/tspc_2/a_630_n680# pll_full_0/divider_0/tspc_2/Z2 0.01fF
C1283 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 0.06fF
C1284 divider_2/and_0/OUT divider_2/and_0/out1 0.31fF
C1285 divider_2/tspc_1/Z4 divider_2/tspc_1/a_630_n680# 0.12fF
C1286 ro_complete_1/a4 ro_complete_1/cbank_1/switch_1/vin 0.09fF
C1287 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z3 0.16fF
C1288 pll_full_1/divider_0/nor_0/A pll_full_1/divider_0/tspc_2/Z4 0.21fF
C1289 ro_complete_0/cbank_1/switch_5/vin ro_complete_0/cbank_1/v 1.30fF
C1290 pll_full_0/pd_0/tspc_r_0/Z2 pll_full_0/pd_0/DIV 0.19fF
C1291 divider_1/tspc_1/Q divider_1/tspc_0/Z4 0.15fF
C1292 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z4 0.28fF
C1293 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/D 0.09fF
C1294 divider_0/prescaler_0/tspc_2/D divider_0/clk 0.26fF
C1295 pll_full_1/pd_0/DOWN pll_full_1/pd_0/tspc_r_1/Qbar 0.02fF
C1296 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_1/B 0.00fF
C1297 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/nand_0/z1 0.07fF
C1298 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.05fF
C1299 pd_0/DIV pd_0/tspc_r_0/Z1 0.17fF
C1300 pd_0/tspc_r_0/Qbar1 pd_0/DOWN 0.11fF
C1301 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/R 0.01fF
C1302 pll_full_1/ro_complete_0/cbank_2/switch_2/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1303 pll_full_0/pd_0/R pll_full_0/pd_0/tspc_r_1/Z2 0.21fF
C1304 divider_2/tspc_1/Z1 divider_2/tspc_1/Z3 0.06fF
C1305 pd_1/tspc_r_1/Z2 pd_1/tspc_r_1/Z4 0.14fF
C1306 ro_complete_0/a2 ro_complete_0/a3 3.09fF
C1307 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/A 0.55fF
C1308 pll_full_1/divider_0/nor_0/B pll_full_1/divider_0/tspc_1/Z4 0.21fF
C1309 divider_2/nor_0/A divider_2/and_0/B 0.08fF
C1310 ro_complete_0/a4 ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1311 pll_full_1/divider_0/and_0/A pll_full_1/divider_0/and_0/B 0.18fF
C1312 ro_complete_1/a2 ro_complete_1/cbank_1/v 0.05fF
C1313 pll_full_0/divbuf_1/OUT pll_full_0/divbuf_1/OUT4 1.11fF
C1314 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Q 0.91fF
C1315 divider_0/mc2 divider_0/nor_1/B 0.15fF
C1316 pll_full_0/ro_complete_0/cbank_2/switch_5/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1317 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/and_0/A 0.26fF
C1318 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Qbar 0.01fF
C1319 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Qbar1 0.12fF
C1320 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Z4 0.36fF
C1321 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/a1 0.14fF
C1322 pll_full_1/pd_0/tspc_r_0/Z3 pll_full_1/pd_0/tspc_r_0/z5 0.11fF
C1323 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/tspc_2/a_630_n680# 0.01fF
C1324 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.05fF
C1325 pd_0/R pd_0/tspc_r_1/Z2 0.21fF
C1326 divider_1/nor_0/B divider_1/and_0/B 0.31fF
C1327 divider_1/prescaler_0/tspc_2/Z4 divider_1/clk 0.12fF
C1328 pll_full_0/filter_0/a_4216_n5230# pll_full_0/divider_0/clk 1.58fF
C1329 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/Z3 0.20fF
C1330 divider_2/prescaler_0/tspc_2/Z2 divider_2/and_0/OUT 0.05fF
C1331 pll_full_1/divider_0/tspc_0/Z4 pll_full_1/divider_0/tspc_0/Z2 0.36fF
C1332 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/prescaler_0/nand_0/z1 0.24fF
C1333 ro_complete_0/cbank_2/switch_3/vin ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1334 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_0/Z4 0.08fF
C1335 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/a_492_n240# 0.00fF
C1336 divider_0/mc2 divider_0/nor_0/A 0.04fF
C1337 divider_0/prescaler_0/tspc_2/Z3 divider_0/prescaler_0/tspc_2/D 0.05fF
C1338 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z2 0.19fF
C1339 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/tspc_1/Z3 0.06fF
C1340 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/a_492_n240# 0.00fF
C1341 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_1/Qbar1 0.30fF
C1342 divider_1/nor_1/Z1 divider_1/nor_0/B 0.18fF
C1343 divider_1/prescaler_0/tspc_1/Z2 divider_1/prescaler_0/tspc_1/Q 0.06fF
C1344 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/switch_0/vin 0.09fF
C1345 pd_1/tspc_r_0/Z1 pd_1/tspc_r_0/Z3 0.09fF
C1346 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/DOWN 0.11fF
C1347 divider_1/nor_0/A divider_1/tspc_2/Q 0.55fF
C1348 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/a_630_n680# 0.01fF
C1349 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.19fF
C1350 pll_full_1/ro_complete_0/a5 pll_full_1/divider_0/clk 0.15fF
C1351 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/tspc_0/D 0.32fF
C1352 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/clk 0.01fF
C1353 pll_full_1/divider_0/prescaler_0/tspc_2/D pll_full_1/divider_0/clk 0.26fF
C1354 ro_complete_1/a2 ro_complete_1/cbank_0/switch_2/vin 0.14fF
C1355 ro_complete_0/a5 ro_complete_0/cbank_2/v 0.08fF
C1356 ro_complete_0/a0 ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1357 divider_0/tspc_1/Z1 divider_0/tspc_1/Z3 0.06fF
C1358 pll_full_1/pd_0/REF pll_full_1/divbuf_1/OUT5 0.00fF
C1359 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/and_pd_0/Out1 0.18fF
C1360 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1361 divider_2/nor_1/B divider_2/nor_0/B 0.47fF
C1362 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Z4 0.65fF
C1363 divider_1/prescaler_0/tspc_0/Z4 divider_1/prescaler_0/tspc_0/D 0.11fF
C1364 pll_full_1/ro_complete_0/a1 pll_full_1/ro_complete_0/cbank_2/v 0.05fF
C1365 pd_1/tspc_r_1/Qbar1 pd_1/tspc_r_1/Qbar 0.01fF
C1366 divider_2/tspc_0/Z2 divider_2/nor_0/B 0.20fF
C1367 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z3 0.11fF
C1368 divider_2/tspc_2/Z1 divider_2/tspc_2/Z3 0.06fF
C1369 ro_complete_0/cbank_0/switch_1/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1370 ro_complete_0/cbank_2/switch_4/vin ro_complete_0/cbank_2/v 1.30fF
C1371 pll_full_0/divbuf_0/OUT4 pll_full_0/divbuf_0/OUT5 20.26fF
C1372 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1373 divider_1/tspc_1/Q divider_1/tspc_0/a_630_n680# 0.01fF
C1374 pll_full_1/pd_0/REF pll_full_1/pd_0/tspc_r_1/Z3 0.65fF
C1375 divider_0/tspc_2/Z2 divider_0/tspc_2/Z4 0.36fF
C1376 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/tspc_0/Z2 0.36fF
C1377 pll_full_1/divbuf_1/OUT pll_full_1/divbuf_1/OUT3 0.26fF
C1378 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT4 20.26fF
C1379 divider_1/tspc_1/Z1 divider_1/tspc_2/Q 0.01fF
C1380 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z1 0.09fF
C1381 divider_2/tspc_1/Z2 divider_2/tspc_1/Z4 0.36fF
C1382 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Z4 0.08fF
C1383 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z3 0.05fF
C1384 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.05fF
C1385 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/clk 0.64fF
C1386 divider_2/prescaler_0/tspc_0/a_740_n680# divider_2/prescaler_0/tspc_0/Z3 0.33fF
C1387 divider_0/nor_1/Z1 divider_0/nor_1/B 0.06fF
C1388 ro_complete_1/cbank_0/switch_5/vin ro_complete_1/a0 0.09fF
C1389 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1390 pll_full_0/ro_complete_0/a5 pll_full_0/divider_0/clk 0.15fF
C1391 divider_0/tspc_0/Z3 divider_0/tspc_0/Z1 0.06fF
C1392 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1393 pll_full_1/pd_0/and_pd_0/Z1 pll_full_1/pd_0/tspc_r_1/Qbar 0.02fF
C1394 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z4 0.65fF
C1395 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 1.07fF
C1396 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_0/Z4 0.12fF
C1397 divider_2/mc2 divider_2/nor_0/B 0.06fF
C1398 pll_full_0/divider_0/prescaler_0/tspc_2/D pll_full_0/divider_0/clk 0.26fF
C1399 pll_full_1/ro_complete_0/cbank_0/switch_4/vin pll_full_1/ro_complete_0/a0 0.13fF
C1400 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.19fF
C1401 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/z5 0.11fF
C1402 divider_2/nor_1/Z1 divider_2/nor_0/B 0.18fF
C1403 divider_1/and_0/OUT divider_1/and_0/Z1 0.04fF
C1404 divider_1/tspc_2/a_630_n680# divider_1/tspc_2/Z2 0.01fF
C1405 divider_1/prescaler_0/tspc_2/Q divider_1/clk 0.05fF
C1406 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/tspc_1/Z3 0.45fF
C1407 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1408 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 0.65fF
C1409 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/divider_0/clk 1.46fF
C1410 divider_2/prescaler_0/Out divider_2/clk 0.51fF
C1411 divider_0/prescaler_0/tspc_0/a_630_n680# divider_0/prescaler_0/Out 0.04fF
C1412 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/switch_0/vin 0.19fF
C1413 pll_full_0/ro_complete_0/cbank_2/switch_3/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1414 divider_0/and_0/OUT divider_0/prescaler_0/tspc_2/Q 0.04fF
C1415 divider_0/prescaler_0/tspc_1/Z3 divider_0/clk 0.45fF
C1416 pll_full_0/divider_0/tspc_1/Z1 pll_full_0/divider_0/nor_0/B 0.03fF
C1417 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/a_630_n680# 0.05fF
C1418 pll_full_0/divider_0/tspc_0/a_630_n680# pll_full_0/divider_0/nor_1/B 0.35fF
C1419 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.08fF
C1420 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z3 0.05fF
C1421 pll_full_0/pd_0/tspc_r_1/Qbar1 pll_full_0/pd_0/tspc_r_1/Z3 0.38fF
C1422 pll_full_0/divider_0/nor_0/A pll_full_0/divider_0/tspc_2/Z2 0.23fF
C1423 pd_1/REF pd_1/tspc_r_1/Qbar1 0.12fF
C1424 divider_2/tspc_0/Z4 divider_2/nor_0/B 0.02fF
C1425 divider_1/and_0/out1 divider_1/and_0/B 0.18fF
C1426 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.00fF
C1427 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/divider_0/clk 1.27fF
C1428 pll_full_0/pd_0/tspc_r_1/Z1 pll_full_0/pd_0/tspc_r_1/Z2 0.71fF
C1429 pll_full_1/divider_0/tspc_2/Z2 pll_full_1/divider_0/tspc_2/Z4 0.36fF
C1430 ro_complete_0/cbank_0/v ro_complete_0/cbank_2/v 0.04fF
C1431 io_clamp_low[1] io_clamp_high[1] 0.53fF
C1432 divider_1/mc2 divider_1/prescaler_0/tspc_2/a_630_n680# 0.33fF
C1433 divider_0/tspc_0/Z3 divider_0/nor_1/B 0.38fF
C1434 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 pll_full_0/divider_0/clk 0.64fF
C1435 divider_2/prescaler_0/tspc_0/a_630_n680# divider_2/prescaler_0/Out 0.04fF
C1436 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_1/B 0.47fF
C1437 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 pll_full_0/divider_0/and_0/OUT 0.06fF
C1438 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.33fF
C1439 pll_full_0/divider_0/prescaler_0/m1_2700_2190# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.38fF
C1440 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/prescaler_0/tspc_0/D 0.11fF
C1441 divider_1/prescaler_0/tspc_2/Z3 divider_1/prescaler_0/tspc_2/Q 0.05fF
C1442 pd_0/tspc_r_0/Z3 pd_0/tspc_r_0/Z2 0.25fF
C1443 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/switch_5/vin 0.20fF
C1444 pd_1/DOWN pd_1/UP 0.46fF
C1445 pll_full_0/pd_0/tspc_r_0/Qbar1 pll_full_0/pd_0/tspc_r_0/z5 0.20fF
C1446 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/tspc_2/a_630_n680# 0.01fF
C1447 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/Z1 0.06fF
C1448 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 0.06fF
C1449 ro_complete_0/cbank_1/switch_3/vin ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1450 divider_2/tspc_1/Q divider_2/nor_1/B 0.22fF
C1451 pll_full_0/divbuf_1/a_492_n240# pll_full_0/divbuf_1/OUT2 0.42fF
C1452 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/ro_complete_0/cbank_1/switch_4/vin 0.20fF
C1453 pll_full_0/ro_complete_0/cbank_1/switch_3/vin pll_full_0/divider_0/clk 1.46fF
C1454 divider_2/tspc_1/Q divider_2/tspc_0/Z2 0.14fF
C1455 divider_1/prescaler_0/m1_2700_2190# divider_1/and_0/OUT 0.14fF
C1456 pll_full_0/divider_0/nor_0/B pll_full_0/divider_0/nor_0/A 1.21fF
C1457 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_2/switch_1/vin 0.09fF
C1458 pll_full_1/ro_complete_0/cbank_0/switch_3/vin pll_full_1/ro_complete_0/cbank_0/v 1.30fF
C1459 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z1 0.71fF
C1460 pd_0/REF pd_0/tspc_r_1/Z3 0.65fF
C1461 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# pll_full_1/divider_0/prescaler_0/Out 0.21fF
C1462 cp_0/a_10_n50# cp_0/vbias 0.19fF
C1463 divider_2/prescaler_0/tspc_2/a_740_n680# divider_2/prescaler_0/tspc_2/Q 0.20fF
C1464 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/D 0.09fF
C1465 pll_full_1/divider_0/and_0/OUT pll_full_1/divider_0/prescaler_0/tspc_2/Q 0.04fF
C1466 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/clk 0.45fF
C1467 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/switch_2/vin 0.20fF
C1468 divider_0/tspc_0/Z3 divider_0/tspc_0/a_630_n680# 0.05fF
C1469 ro_complete_1/a0 ro_complete_1/cbank_2/switch_4/vin 0.13fF
C1470 ro_complete_1/cbank_0/v ro_complete_1/cbank_1/v 1.27fF
C1471 pll_full_0/ro_complete_0/cbank_0/v pll_full_0/divider_0/clk 1.27fF
C1472 divider_0/prescaler_0/tspc_2/Z4 divider_0/prescaler_0/tspc_2/D 0.11fF
C1473 pll_full_0/divider_0/tspc_0/Z1 pll_full_0/divider_0/tspc_0/Z2 1.07fF
C1474 pll_full_1/divbuf_1/OUT5 pll_full_1/divbuf_1/OUT 43.38fF
C1475 pll_full_0/divider_0/and_0/OUT pll_full_0/divider_0/and_0/out1 0.31fF
C1476 pll_full_1/ro_complete_0/cbank_2/switch_1/vin pll_full_1/ro_complete_0/cbank_2/switch_2/vin 0.20fF
C1477 divider_2/prescaler_0/tspc_1/Z2 divider_2/prescaler_0/Out 0.19fF
C1478 pd_1/R pd_1/tspc_r_1/Qbar 0.03fF
C1479 pll_full_1/divider_0/tspc_2/Q pll_full_1/divider_0/nor_0/B 0.22fF
C1480 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/nor_1/B 0.38fF
C1481 ro_complete_1/cbank_1/switch_0/vin ro_complete_1/cbank_1/switch_1/vin 0.19fF
C1482 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/tspc_0/D 0.04fF
C1483 divider_2/prescaler_0/tspc_1/Q divider_2/prescaler_0/nand_1/z1 0.22fF
C1484 ro_complete_1/cbank_1/switch_1/vin ro_complete_1/cbank_1/v 1.30fF
C1485 ro_complete_0/a0 ro_complete_0/cbank_1/v 0.05fF
C1486 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divider_0/tspc_0/Z1 0.06fF
C1487 divider_1/tspc_1/Q divider_1/tspc_1/a_630_n680# 0.04fF
C1488 divider_1/nor_0/Z1 divider_1/nor_0/B 0.06fF
C1489 divider_0/prescaler_0/tspc_2/Z3 divider_0/clk 0.45fF
C1490 pll_full_0/divider_0/tspc_1/Z2 pll_full_0/divider_0/tspc_1/Z4 0.36fF
C1491 pll_full_0/divider_0/tspc_1/a_630_n680# pll_full_0/divider_0/nor_0/B 0.35fF
C1492 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/nor_1/B 0.22fF
C1493 pll_full_0/pd_0/DIV pll_full_0/pd_0/tspc_r_0/Z4 0.02fF
C1494 divider_2/mc2 divider_2/and_0/out1 0.06fF
C1495 divider_2/prescaler_0/m1_2700_2190# divider_2/and_0/OUT 0.14fF
C1496 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Out1 0.33fF
C1497 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Z4 0.28fF
C1498 pd_1/DOWN pd_1/and_pd_0/Out1 0.12fF
C1499 pd_1/tspc_r_1/Z1 pd_1/tspc_r_1/Z2 0.71fF
C1500 pd_1/tspc_r_1/Z3 pd_1/tspc_r_1/Z4 0.20fF
C1501 pd_1/REF pd_1/tspc_r_1/z5 0.04fF
C1502 pd_1/tspc_r_0/Z3 pd_1/tspc_r_0/Z4 0.20fF
C1503 pd_1/DIV pd_1/tspc_r_0/z5 0.04fF
C1504 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.13fF
C1505 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/and_0/OUT 0.14fF
C1506 divider_2/tspc_2/Z1 divider_2/tspc_2/Z4 0.00fF
C1507 ro_complete_1/a3 ro_complete_1/cbank_1/switch_2/vin 0.09fF
C1508 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/cbank_0/v 1.30fF
C1509 ro_complete_0/cbank_2/switch_0/vin ro_complete_0/cbank_2/v 1.45fF
C1510 pll_full_0/divbuf_0/OUT3 pll_full_0/divbuf_0/OUT2 1.37fF
C1511 divider_2/tspc_1/Q divider_2/tspc_0/Z4 0.15fF
C1512 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/clk 0.14fF
C1513 divider_0/mc2 divider_0/nor_0/B 0.06fF
C1514 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1515 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 pll_full_0/divider_0/clk 0.45fF
C1516 pll_full_1/ro_complete_0/a4 pll_full_1/ro_complete_0/cbank_1/switch_1/vin 0.09fF
C1517 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/and_0/OUT 0.05fF
C1518 divider_1/tspc_1/Z3 divider_1/tspc_2/Q 0.45fF
C1519 divider_1/tspc_1/Z2 divider_1/tspc_1/a_630_n680# 0.01fF
C1520 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_2/Q 0.19fF
C1521 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/clk 0.01fF
C1522 pll_full_0/pd_0/R pll_full_0/pd_0/and_pd_0/Z1 0.02fF
C1523 divider_2/prescaler_0/Out divider_2/prescaler_0/tspc_1/Q 0.91fF
C1524 divider_2/prescaler_0/tspc_2/Z1 divider_2/prescaler_0/tspc_2/Z2 1.07fF
C1525 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Z4 0.12fF
C1526 ro_complete_0/a4 ro_complete_0/cbank_1/switch_0/vin 0.12fF
C1527 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 pll_full_1/divider_0/prescaler_0/tspc_2/D 0.11fF
C1528 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/clk 0.12fF
C1529 ro_complete_0/a2 ro_complete_0/cbank_2/switch_2/vin 0.14fF
C1530 ro_complete_0/cbank_0/switch_2/vin ro_complete_0/cbank_0/v 1.30fF
C1531 divider_0/tspc_2/Q divider_0/tspc_1/Z2 0.14fF
C1532 divider_0/prescaler_0/tspc_0/Z2 divider_0/prescaler_0/tspc_0/Z4 0.36fF
C1533 divider_0/prescaler_0/tspc_0/Z3 divider_0/prescaler_0/Out 0.05fF
C1534 ro_complete_1/a3 ro_complete_1/cbank_1/v 0.05fF
C1535 pll_full_0/pd_0/DIV pll_full_0/divbuf_0/OUT2 0.06fF
C1536 pll_full_0/ro_complete_0/a5 pll_full_0/ro_complete_0/cbank_1/switch_0/vin 0.09fF
C1537 pll_full_0/ro_complete_0/cbank_0/switch_4/vin pll_full_0/ro_complete_0/cbank_0/v 1.30fF
C1538 divider_0/tspc_1/Z2 divider_0/nor_0/A 0.15fF
C1539 divider_0/prescaler_0/Out divider_0/tspc_2/Z3 0.45fF
C1540 divider_0/prescaler_0/tspc_2/Z1 divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1541 divider_0/prescaler_0/tspc_1/Z3 divider_0/prescaler_0/tspc_1/Q 0.21fF
C1542 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/clk 0.14fF
C1543 pll_full_0/pd_0/DIV pll_full_0/divider_0/and_0/OUT 0.01fF
C1544 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 0.16fF
C1545 pll_full_1/pd_0/DIV pll_full_1/divbuf_0/OUT2 0.06fF
C1546 divider_2/prescaler_0/tspc_0/Z3 divider_2/prescaler_0/tspc_0/Z1 0.06fF
C1547 divider_0/and_0/B divider_0/and_0/Z1 0.07fF
C1548 pll_full_1/ro_complete_0/cbank_2/switch_3/vin pll_full_1/ro_complete_0/cbank_2/switch_4/vin 0.20fF
C1549 pll_full_0/divider_0/prescaler_0/tspc_1/Q pll_full_0/divider_0/prescaler_0/tspc_0/D 0.32fF
C1550 pd_1/R pd_1/REF 0.61fF
C1551 pll_full_1/pd_0/DIV pll_full_1/divider_0/and_0/OUT 0.01fF
C1552 divider_1/nor_0/A divider_1/tspc_2/Z2 0.23fF
C1553 divider_1/prescaler_0/tspc_0/D divider_1/clk 0.29fF
C1554 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Out1 0.12fF
C1555 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 pll_full_1/divider_0/clk 0.45fF
C1556 ro_complete_0/a3 ro_complete_0/cbank_1/v 0.05fF
C1557 ro_complete_1/cbank_2/switch_0/vin ro_complete_1/cbank_2/v 1.45fF
C1558 divider_0/prescaler_0/tspc_1/Z4 divider_0/clk 0.12fF
C1559 divider_0/mc2 divider_0/and_0/B 0.20fF
C1560 pll_full_1/cp_0/a_1710_0# pll_full_1/cp_0/down 0.32fF
C1561 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/nor_0/B 0.38fF
C1562 pll_full_0/divider_0/tspc_1/Q pll_full_0/divider_0/tspc_1/a_630_n680# 0.04fF
C1563 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 1.07fF
C1564 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Z4 0.12fF
C1565 io_analog[6] io_clamp_high[2] 0.53fF
C1566 divider_2/nor_1/B divider_2/Out 0.22fF
C1567 divider_1/prescaler_0/tspc_2/a_740_n680# divider_1/prescaler_0/tspc_2/Z3 0.33fF
C1568 pll_full_1/ro_complete_0/a5 pll_full_1/ro_complete_0/cbank_2/v 0.08fF
C1569 pll_full_1/ro_complete_0/a0 pll_full_1/ro_complete_0/cbank_1/switch_5/vin 0.09fF
C1570 pll_full_0/divider_0/tspc_2/Z1 pll_full_0/divider_0/tspc_2/Z3 0.06fF
C1571 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/prescaler_0/tspc_1/Z3 0.05fF
C1572 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 0.65fF
C1573 pll_full_0/cp_0/a_1710_0# pll_full_0/cp_0/down 0.32fF
C1574 pll_full_0/pd_0/DOWN pll_full_0/pd_0/and_pd_0/Z1 0.07fF
C1575 ro_complete_1/a4 ro_complete_1/cbank_2/v 0.05fF
C1576 ro_complete_1/cbank_0/switch_2/vin ro_complete_1/a3 0.09fF
C1577 pll_full_0/ro_complete_0/a2 pll_full_0/ro_complete_0/cbank_1/switch_3/vin 0.09fF
C1578 divider_1/mc2 divider_1/nor_0/B 0.06fF
C1579 divider_0/tspc_2/Q divider_0/tspc_2/a_630_n680# 0.04fF
C1580 divider_0/tspc_1/Z2 divider_0/tspc_1/a_630_n680# 0.01fF
C1581 divider_0/prescaler_0/tspc_1/a_630_n680# divider_0/prescaler_0/tspc_1/Z2 0.01fF
C1582 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 pll_full_0/divider_0/clk 0.12fF
C1583 divider_1/nor_1/B divider_1/nor_0/B 0.47fF
C1584 divider_0/tspc_2/a_630_n680# divider_0/nor_0/A 0.35fF
C1585 divider_0/prescaler_0/tspc_1/Q divider_0/clk 0.60fF
C1586 pll_full_1/divbuf_0/OUT3 pll_full_1/divbuf_0/OUT4 5.16fF
C1587 pll_full_1/ro_complete_0/cbank_0/switch_1/vin pll_full_1/ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1588 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z4 0.08fF
C1589 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Z3 0.05fF
C1590 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# pll_full_0/divider_0/prescaler_0/tspc_1/Q 0.04fF
C1591 pd_0/tspc_r_0/Qbar1 pd_0/tspc_r_0/Qbar 0.01fF
C1592 pd_0/tspc_r_0/Z3 pd_0/R 0.27fF
C1593 pll_full_1/ro_complete_0/cbank_2/switch_4/vin pll_full_1/ro_complete_0/cbank_2/v 1.30fF
C1594 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z4 0.20fF
C1595 ro_complete_0/a2 ro_complete_0/a1 3.23fF
C1596 pll_full_1/divider_0/prescaler_0/Out pll_full_1/divider_0/nor_0/A 0.15fF
C1597 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 0.00fF
C1598 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1599 divider_1/prescaler_0/tspc_0/Z3 divider_1/prescaler_0/tspc_0/a_630_n680# 0.05fF
C1600 ro_complete_1/cbank_0/switch_3/vin ro_complete_1/cbank_0/switch_2/vin 0.20fF
C1601 pll_full_1/divider_0/and_0/B pll_full_1/divider_0/and_0/Z1 0.07fF
C1602 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z2 0.01fF
C1603 divider_0/nor_1/Z1 divider_0/nor_0/B 0.18fF
C1604 ro_complete_0/cbank_2/switch_5/vin ro_complete_0/cbank_2/v 1.30fF
C1605 pll_full_0/divbuf_0/OUT5 pll_full_0/divbuf_0/a_492_n240# 0.01fF
C1606 pll_full_1/pd_0/tspc_r_1/z5 pll_full_1/pd_0/tspc_r_1/Qbar1 0.20fF
C1607 divider_2/tspc_1/Q divider_2/tspc_0/a_630_n680# 0.01fF
C1608 pll_full_1/pd_0/tspc_r_0/Z4 pll_full_1/pd_0/tspc_r_0/Z2 0.14fF
C1609 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 pll_full_0/divider_0/clk 0.45fF
C1610 divider_1/prescaler_0/m1_2700_2190# divider_1/prescaler_0/tspc_2/D 0.16fF
C1611 pd_0/tspc_r_1/Z3 pd_0/tspc_r_1/Qbar1 0.38fF
C1612 divider_1/and_0/OUT divider_1/and_0/out1 0.31fF
C1613 divider_1/tspc_1/Z4 divider_1/tspc_1/a_630_n680# 0.12fF
C1614 pll_full_0/pd_0/tspc_r_1/Z3 pll_full_0/pd_0/tspc_r_1/Z2 0.25fF
C1615 divider_2/prescaler_0/tspc_2/a_630_n680# divider_2/prescaler_0/tspc_2/Q 0.04fF
C1616 divider_2/prescaler_0/tspc_1/a_630_n680# divider_2/clk 0.01fF
C1617 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 pll_full_1/divider_0/clk 0.12fF
C1618 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Z4 0.01fF
C1619 pll_full_0/ro_complete_0/a3 pll_full_0/ro_complete_0/cbank_2/switch_2/vin 0.09fF
C1620 pll_full_1/cp_0/a_1710_0# pll_full_1/pd_0/DOWN 0.04fF
C1621 pll_full_0/divider_0/tspc_1/Z3 pll_full_0/divider_0/tspc_1/Q 0.05fF
C1622 pll_full_0/divider_0/prescaler_0/Out pll_full_0/divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1623 pll_full_0/divider_0/nor_1/Z1 pll_full_0/divider_0/nor_1/B 0.06fF
C1624 divider_1/tspc_1/Z1 divider_1/tspc_1/Z3 0.06fF
C1625 pll_full_1/pd_0/R pll_full_1/pd_0/tspc_r_0/Z2 0.21fF
C1626 pd_1/tspc_r_0/Qbar1 pd_1/tspc_r_0/Z3 0.38fF
C1627 pd_1/tspc_r_0/Z2 pd_1/tspc_r_0/Z4 0.14fF
C1628 pd_0/tspc_r_1/Qbar pd_0/and_pd_0/Z1 0.02fF
C1629 divider_2/prescaler_0/tspc_1/Z1 divider_2/prescaler_0/tspc_1/Z3 0.06fF
C1630 divider_1/nor_0/A divider_1/and_0/B 0.08fF
C1631 pll_full_0/pd_0/tspc_r_1/Z4 pll_full_0/pd_0/tspc_r_1/Z2 0.14fF
C1632 pll_full_0/pd_0/tspc_r_0/Z4 pll_full_0/pd_0/tspc_r_0/z5 0.04fF
C1633 divider_2/nor_0/B divider_2/tspc_1/a_630_n680# 0.35fF
C1634 divider_2/prescaler_0/tspc_2/Q divider_2/prescaler_0/nand_1/z1 0.01fF
C1635 divider_2/prescaler_0/tspc_2/Z2 divider_2/clk 0.11fF
C1636 pll_full_1/divider_0/tspc_2/a_630_n680# pll_full_1/divider_0/nor_0/A 0.35fF
C1637 pll_full_1/divider_0/prescaler_0/tspc_1/Q pll_full_1/divider_0/clk 0.60fF
C1638 divider_1/prescaler_0/tspc_0/a_740_n680# divider_1/prescaler_0/tspc_1/Q 0.15fF
C1639 divider_0/tspc_1/Z3 divider_0/tspc_1/Q 0.05fF
C1640 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Z4 0.01fF
C1641 divider_0/prescaler_0/Out divider_0/prescaler_0/tspc_1/Z1 0.08fF
C1642 divider_0/nor_1/Z1 divider_0/and_0/B 0.78fF
C1643 pll_full_0/ro_complete_0/cbank_2/switch_1/vin pll_full_0/ro_complete_0/cbank_2/v 1.30fF
C1644 divider_0/nor_1/B divider_0/tspc_0/Z1 0.03fF
C1645 divider_0/prescaler_0/tspc_2/Z4 divider_0/clk 0.12fF
C1646 pll_full_0/divider_0/tspc_0/Z4 pll_full_0/divider_0/nor_1/B 0.22fF
C1647 divider_2/prescaler_0/m1_2700_2190# divider_2/prescaler_0/tspc_2/D 0.16fF
C1648 divider_1/prescaler_0/tspc_2/Z2 divider_1/and_0/OUT 0.05fF
C1649 pll_full_1/ro_complete_0/cbank_0/v pll_full_1/ro_complete_0/cbank_2/v 0.04fF
C1650 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 pll_full_1/divider_0/prescaler_0/tspc_1/Q 0.21fF
C1651 pll_full_1/divider_0/prescaler_0/m1_2700_2190# pll_full_1/divider_0/prescaler_0/tspc_2/D 0.16fF
C1652 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 pll_full_1/divider_0/prescaler_0/tspc_0/D 0.03fF
C1653 ro_complete_0/cbank_0/switch_3/vin ro_complete_0/cbank_0/switch_2/vin 0.20fF
C1654 pll_full_0/pd_0/tspc_r_1/z5 pll_full_0/pd_0/UP 0.03fF
C1655 divider_2/tspc_2/Z3 divider_2/tspc_2/Z4 0.65fF
C1656 ro_complete_1/a2 ro_complete_1/cbank_2/switch_2/vin 0.14fF
C1657 ro_complete_1/a3 ro_complete_1/cbank_2/switch_1/vin 0.13fF
C1658 pll_full_0/ro_complete_0/cbank_0/switch_3/vin pll_full_0/ro_complete_0/cbank_0/switch_4/vin 0.20fF
C1659 divider_0/tspc_1/Z1 divider_0/tspc_1/Z4 0.00fF
C1660 divider_0/prescaler_0/tspc_0/a_740_n680# divider_0/prescaler_0/tspc_1/Q 0.15fF
C1661 pll_full_0/divider_0/tspc_0/Z3 pll_full_0/divbuf_0/IN 0.05fF
C1662 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 pll_full_0/divider_0/clk 0.12fF
C1663 pll_full_1/pd_0/DOWN pll_full_1/pd_0/R 0.36fF
C1664 pll_full_1/pd_0/DIV pll_full_1/pd_0/tspc_r_0/z5 0.04fF
C1665 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# pll_full_0/divider_0/prescaler_0/tspc_2/Q 0.20fF
C1666 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 pll_full_0/divider_0/prescaler_0/tspc_2/D 0.09fF
C1667 pll_full_1/ro_complete_0/cbank_1/switch_3/vin pll_full_1/ro_complete_0/cbank_1/switch_2/vin 0.20fF
C1668 divider_1/prescaler_0/tspc_1/Q divider_1/prescaler_0/tspc_0/D 0.32fF
C1669 divider_1/prescaler_0/tspc_2/a_630_n680# divider_1/clk 0.01fF
C1670 pll_full_1/divider_0/tspc_0/Z3 pll_full_1/divider_0/tspc_0/a_630_n680# 0.05fF
C1671 filter_0/a_4216_n5230# filter_0/v 0.91fF
C1672 divider_2/prescaler_0/tspc_2/Z2 divider_2/prescaler_0/tspc_2/Z3 0.16fF
C1673 ro_complete_0/cbank_0/switch_4/vin ro_complete_0/cbank_0/switch_5/vin 0.20fF
C1674 ro_complete_1/a5 ro_complete_1/cbank_2/v 0.08fF
Xpd_0 vdda1 vssa1 pd_0/REF pd_0/DIV pd_0/UP pd_0/DOWN pd_0/R pd
Xpd_1 vdda1 vssa1 pd_1/REF pd_1/DIV pd_1/UP pd_1/DOWN pd_1/R pd
Xcp_0 cp_0/vbias vdda1 gnd cp_0/out cp_0/down cp_0/upbar cp
Xfilter_0 vssa1 filter_0/v filter
Xro_complete_0 ro_complete_0/a0 ro_complete_0/a1 ro_complete_0/a5 ro_complete_0/a4
+ ro_complete_0/a3 ro_complete_0/a2 ro_complete
Xro_complete_1 ro_complete_1/a0 ro_complete_1/a1 ro_complete_1/a5 ro_complete_1/a4
+ ro_complete_1/a3 ro_complete_1/a2 ro_complete
Xdivider_0 gnd vdd divider_0/Out divider_0/clk divider_0/mc2 divider
Xdivider_1 vssa1 vdda1 divider_1/Out divider_1/clk divider_1/mc2 divider
Xdivider_2 vssa1 vdda1 divider_2/Out divider_2/clk divider_2/mc2 divider
Xpll_full_0 vdda1 pll_full
Xpll_full_1 vdda1 pll_full
C1675 io_analog[4] vssa1 43.96fF
C1676 io_analog[5] vssa1 44.13fF
C1677 io_analog[6] vssa1 43.46fF
C1678 io_in_3v3[0] vssa1 0.61fF
C1679 io_oeb[26] vssa1 0.61fF
C1680 io_in[0] vssa1 0.61fF
C1681 io_out[26] vssa1 0.61fF
C1682 io_out[0] vssa1 0.61fF
C1683 io_in[26] vssa1 0.61fF
C1684 io_oeb[0] vssa1 0.61fF
C1685 io_in_3v3[26] vssa1 0.61fF
C1686 io_in_3v3[1] vssa1 0.61fF
C1687 io_oeb[25] vssa1 0.61fF
C1688 io_in[1] vssa1 0.61fF
C1689 io_out[25] vssa1 0.61fF
C1690 io_out[1] vssa1 0.61fF
C1691 io_in[25] vssa1 0.61fF
C1692 io_oeb[1] vssa1 0.61fF
C1693 io_in_3v3[25] vssa1 0.61fF
C1694 io_in_3v3[2] vssa1 0.61fF
C1695 io_oeb[24] vssa1 0.61fF
C1696 io_in[2] vssa1 0.61fF
C1697 io_out[24] vssa1 0.61fF
C1698 io_out[2] vssa1 0.61fF
C1699 io_in[24] vssa1 0.61fF
C1700 io_oeb[2] vssa1 0.61fF
C1701 io_in_3v3[24] vssa1 0.61fF
C1702 io_in_3v3[3] vssa1 0.61fF
C1703 gpio_noesd[17] vssa1 2.32fF
C1704 io_in[3] vssa1 0.61fF
C1705 gpio_analog[17] vssa1 2.30fF
C1706 io_out[3] vssa1 0.61fF
C1707 io_oeb[3] vssa1 0.61fF
C1708 io_in_3v3[4] vssa1 0.61fF
C1709 io_in[4] vssa1 0.61fF
C1710 io_out[4] vssa1 0.61fF
C1711 io_oeb[4] vssa1 0.61fF
C1712 io_oeb[23] vssa1 0.61fF
C1713 io_out[23] vssa1 0.61fF
C1714 io_in[23] vssa1 0.61fF
C1715 io_in_3v3[23] vssa1 0.61fF
C1716 gpio_noesd[16] vssa1 2.30fF
C1717 gpio_analog[16] vssa1 2.30fF
C1718 io_in_3v3[5] vssa1 0.61fF
C1719 io_in[5] vssa1 0.61fF
C1720 io_out[5] vssa1 0.61fF
C1721 io_oeb[5] vssa1 0.61fF
C1722 io_oeb[22] vssa1 0.61fF
C1723 io_out[22] vssa1 0.61fF
C1724 io_in[22] vssa1 0.61fF
C1725 io_in_3v3[22] vssa1 0.61fF
C1726 gpio_noesd[15] vssa1 2.31fF
C1727 gpio_analog[15] vssa1 2.30fF
C1728 io_in_3v3[6] vssa1 0.61fF
C1729 io_in[6] vssa1 0.61fF
C1730 io_out[6] vssa1 0.61fF
C1731 io_oeb[6] vssa1 0.61fF
C1732 io_oeb[21] vssa1 0.61fF
C1733 io_out[21] vssa1 0.61fF
C1734 io_in[21] vssa1 0.61fF
C1735 io_in_3v3[21] vssa1 0.61fF
C1736 gpio_noesd[14] vssa1 2.30fF
C1737 gpio_analog[14] vssa1 2.29fF
C1738 vssd2 vssa1 38.54fF
C1739 vssd1 vssa1 13.04fF
C1740 vdda2 vssa1 38.30fF
C1741 io_oeb[20] vssa1 0.61fF
C1742 io_out[20] vssa1 0.61fF
C1743 io_in[20] vssa1 0.61fF
C1744 io_in_3v3[20] vssa1 0.61fF
C1745 gpio_noesd[13] vssa1 2.31fF
C1746 gpio_analog[13] vssa1 2.30fF
C1747 gpio_analog[0] vssa1 0.61fF
C1748 gpio_noesd[0] vssa1 0.61fF
C1749 io_in_3v3[7] vssa1 0.61fF
C1750 io_in[7] vssa1 0.61fF
C1751 io_out[7] vssa1 0.61fF
C1752 io_oeb[7] vssa1 0.61fF
C1753 io_oeb[19] vssa1 0.61fF
C1754 io_out[19] vssa1 0.61fF
C1755 io_in[19] vssa1 0.61fF
C1756 io_in_3v3[19] vssa1 0.61fF
C1757 gpio_noesd[12] vssa1 2.32fF
C1758 gpio_analog[12] vssa1 2.30fF
C1759 gpio_analog[1] vssa1 0.61fF
C1760 gpio_noesd[1] vssa1 0.61fF
C1761 io_in_3v3[8] vssa1 0.61fF
C1762 io_in[8] vssa1 0.61fF
C1763 io_out[8] vssa1 0.61fF
C1764 io_oeb[8] vssa1 0.61fF
C1765 io_oeb[18] vssa1 0.61fF
C1766 io_out[18] vssa1 0.61fF
C1767 io_in[18] vssa1 0.61fF
C1768 io_in_3v3[18] vssa1 0.61fF
C1769 gpio_noesd[11] vssa1 2.30fF
C1770 gpio_analog[11] vssa1 2.29fF
C1771 gpio_analog[2] vssa1 0.61fF
C1772 gpio_noesd[2] vssa1 0.61fF
C1773 io_in_3v3[9] vssa1 0.61fF
C1774 io_in[9] vssa1 0.61fF
C1775 io_out[9] vssa1 0.61fF
C1776 io_oeb[9] vssa1 0.61fF
C1777 io_oeb[17] vssa1 0.61fF
C1778 io_out[17] vssa1 0.61fF
C1779 io_in[17] vssa1 0.61fF
C1780 io_in_3v3[17] vssa1 0.61fF
C1781 gpio_noesd[10] vssa1 2.31fF
C1782 gpio_analog[10] vssa1 2.29fF
C1783 gpio_analog[3] vssa1 0.61fF
C1784 gpio_noesd[3] vssa1 0.61fF
C1785 io_in_3v3[10] vssa1 0.61fF
C1786 io_in[10] vssa1 0.61fF
C1787 io_out[10] vssa1 0.61fF
C1788 io_oeb[10] vssa1 0.61fF
C1789 io_oeb[16] vssa1 0.61fF
C1790 io_out[16] vssa1 0.61fF
C1791 io_in[16] vssa1 0.61fF
C1792 io_in_3v3[16] vssa1 0.61fF
C1793 gpio_noesd[9] vssa1 2.28fF
C1794 gpio_analog[9] vssa1 2.28fF
C1795 gpio_analog[4] vssa1 0.61fF
C1796 gpio_noesd[4] vssa1 0.61fF
C1797 io_in_3v3[11] vssa1 0.61fF
C1798 io_in[11] vssa1 0.61fF
C1799 io_out[11] vssa1 0.61fF
C1800 io_oeb[11] vssa1 0.61fF
C1801 io_oeb[15] vssa1 0.61fF
C1802 io_out[15] vssa1 0.61fF
C1803 io_in[15] vssa1 0.61fF
C1804 io_in_3v3[15] vssa1 0.61fF
C1805 gpio_noesd[8] vssa1 2.28fF
C1806 gpio_analog[8] vssa1 2.26fF
C1807 gpio_analog[5] vssa1 0.61fF
C1808 gpio_noesd[5] vssa1 0.61fF
C1809 io_in_3v3[12] vssa1 0.61fF
C1810 io_in[12] vssa1 0.61fF
C1811 io_out[12] vssa1 0.61fF
C1812 io_oeb[12] vssa1 0.61fF
C1813 io_oeb[14] vssa1 0.61fF
C1814 io_out[14] vssa1 0.61fF
C1815 io_in[14] vssa1 0.61fF
C1816 io_in_3v3[14] vssa1 0.61fF
C1817 gpio_noesd[7] vssa1 2.30fF
C1818 gpio_analog[7] vssa1 2.28fF
C1819 vssa2 vssa1 38.35fF
C1820 gpio_analog[6] vssa1 5.71fF
C1821 gpio_noesd[6] vssa1 5.70fF
C1822 io_in_3v3[13] vssa1 0.61fF
C1823 io_in[13] vssa1 0.61fF
C1824 io_out[13] vssa1 0.61fF
C1825 io_oeb[13] vssa1 0.61fF
C1826 vccd1 vssa1 39.84fF
C1827 vccd2 vssa1 38.46fF
C1828 io_analog[0] vssa1 19.99fF
C1829 io_analog[10] vssa1 19.36fF
C1830 io_analog[1] vssa1 13.17fF
C1831 io_analog[2] vssa1 12.57fF
C1832 io_analog[3] vssa1 12.83fF
C1833 io_clamp_high[0] vssa1 3.58fF
C1834 io_clamp_low[0] vssa1 3.58fF
C1835 io_clamp_high[1] vssa1 3.58fF
C1836 io_clamp_low[1] vssa1 3.58fF
C1837 io_clamp_high[2] vssa1 3.58fF
C1838 io_clamp_low[2] vssa1 3.58fF
C1839 io_analog[7] vssa1 12.74fF
C1840 io_analog[8] vssa1 13.08fF
C1841 io_analog[9] vssa1 13.08fF
C1842 user_irq[2] vssa1 0.63fF
C1843 user_irq[1] vssa1 0.63fF
C1844 user_irq[0] vssa1 0.63fF
C1845 user_clock2 vssa1 0.63fF
C1846 la_oenb[127] vssa1 0.63fF
C1847 la_data_out[127] vssa1 0.63fF
C1848 la_data_in[127] vssa1 0.63fF
C1849 la_oenb[126] vssa1 0.63fF
C1850 la_data_out[126] vssa1 0.63fF
C1851 la_data_in[126] vssa1 0.63fF
C1852 la_oenb[125] vssa1 0.63fF
C1853 la_data_out[125] vssa1 0.63fF
C1854 la_data_in[125] vssa1 0.63fF
C1855 la_oenb[124] vssa1 0.63fF
C1856 la_data_out[124] vssa1 0.63fF
C1857 la_data_in[124] vssa1 0.63fF
C1858 la_oenb[123] vssa1 0.63fF
C1859 la_data_out[123] vssa1 0.63fF
C1860 la_data_in[123] vssa1 0.63fF
C1861 la_oenb[122] vssa1 0.63fF
C1862 la_data_out[122] vssa1 0.63fF
C1863 la_data_in[122] vssa1 0.63fF
C1864 la_oenb[121] vssa1 0.63fF
C1865 la_data_out[121] vssa1 0.63fF
C1866 la_data_in[121] vssa1 0.63fF
C1867 la_oenb[120] vssa1 0.63fF
C1868 la_data_out[120] vssa1 0.63fF
C1869 la_data_in[120] vssa1 0.63fF
C1870 la_oenb[119] vssa1 0.63fF
C1871 la_data_out[119] vssa1 0.63fF
C1872 la_data_in[119] vssa1 0.63fF
C1873 la_oenb[118] vssa1 0.63fF
C1874 la_data_out[118] vssa1 0.63fF
C1875 la_data_in[118] vssa1 0.63fF
C1876 la_oenb[117] vssa1 0.63fF
C1877 la_data_out[117] vssa1 0.63fF
C1878 la_data_in[117] vssa1 0.63fF
C1879 la_oenb[116] vssa1 0.63fF
C1880 la_data_out[116] vssa1 0.63fF
C1881 la_data_in[116] vssa1 0.63fF
C1882 la_oenb[115] vssa1 0.63fF
C1883 la_data_out[115] vssa1 0.63fF
C1884 la_data_in[115] vssa1 0.63fF
C1885 la_oenb[114] vssa1 0.63fF
C1886 la_data_out[114] vssa1 0.63fF
C1887 la_data_in[114] vssa1 0.63fF
C1888 la_oenb[113] vssa1 0.63fF
C1889 la_data_out[113] vssa1 0.63fF
C1890 la_data_in[113] vssa1 0.63fF
C1891 la_oenb[112] vssa1 0.63fF
C1892 la_data_out[112] vssa1 0.63fF
C1893 la_data_in[112] vssa1 0.63fF
C1894 la_oenb[111] vssa1 0.63fF
C1895 la_data_out[111] vssa1 0.63fF
C1896 la_data_in[111] vssa1 0.63fF
C1897 la_oenb[110] vssa1 0.63fF
C1898 la_data_out[110] vssa1 0.63fF
C1899 la_data_in[110] vssa1 0.63fF
C1900 la_oenb[109] vssa1 0.63fF
C1901 la_data_out[109] vssa1 0.63fF
C1902 la_data_in[109] vssa1 0.63fF
C1903 la_oenb[108] vssa1 0.63fF
C1904 la_data_out[108] vssa1 0.63fF
C1905 la_data_in[108] vssa1 0.63fF
C1906 la_oenb[107] vssa1 0.63fF
C1907 la_data_out[107] vssa1 0.63fF
C1908 la_data_in[107] vssa1 0.63fF
C1909 la_oenb[106] vssa1 0.63fF
C1910 la_data_out[106] vssa1 0.63fF
C1911 la_data_in[106] vssa1 0.63fF
C1912 la_oenb[105] vssa1 0.63fF
C1913 la_data_out[105] vssa1 0.63fF
C1914 la_data_in[105] vssa1 0.63fF
C1915 la_oenb[104] vssa1 0.63fF
C1916 la_data_out[104] vssa1 0.63fF
C1917 la_data_in[104] vssa1 0.63fF
C1918 la_oenb[103] vssa1 0.63fF
C1919 la_data_out[103] vssa1 0.63fF
C1920 la_data_in[103] vssa1 0.63fF
C1921 la_oenb[102] vssa1 0.63fF
C1922 la_data_out[102] vssa1 0.63fF
C1923 la_data_in[102] vssa1 0.63fF
C1924 la_oenb[101] vssa1 0.63fF
C1925 la_data_out[101] vssa1 0.63fF
C1926 la_data_in[101] vssa1 0.63fF
C1927 la_oenb[100] vssa1 0.63fF
C1928 la_data_out[100] vssa1 0.63fF
C1929 la_data_in[100] vssa1 0.63fF
C1930 la_oenb[99] vssa1 0.63fF
C1931 la_data_out[99] vssa1 0.63fF
C1932 la_data_in[99] vssa1 0.63fF
C1933 la_oenb[98] vssa1 0.63fF
C1934 la_data_out[98] vssa1 0.63fF
C1935 la_data_in[98] vssa1 0.63fF
C1936 la_oenb[97] vssa1 0.63fF
C1937 la_data_out[97] vssa1 0.63fF
C1938 la_data_in[97] vssa1 0.63fF
C1939 la_oenb[96] vssa1 0.63fF
C1940 la_data_out[96] vssa1 0.63fF
C1941 la_data_in[96] vssa1 0.63fF
C1942 la_oenb[95] vssa1 0.63fF
C1943 la_data_out[95] vssa1 0.63fF
C1944 la_data_in[95] vssa1 0.63fF
C1945 la_oenb[94] vssa1 0.63fF
C1946 la_data_out[94] vssa1 0.63fF
C1947 la_data_in[94] vssa1 0.63fF
C1948 la_oenb[93] vssa1 0.63fF
C1949 la_data_out[93] vssa1 0.63fF
C1950 la_data_in[93] vssa1 0.63fF
C1951 la_oenb[92] vssa1 0.63fF
C1952 la_data_out[92] vssa1 0.63fF
C1953 la_data_in[92] vssa1 0.63fF
C1954 la_oenb[91] vssa1 0.63fF
C1955 la_data_out[91] vssa1 0.63fF
C1956 la_data_in[91] vssa1 0.63fF
C1957 la_oenb[90] vssa1 0.63fF
C1958 la_data_out[90] vssa1 0.63fF
C1959 la_data_in[90] vssa1 0.63fF
C1960 la_oenb[89] vssa1 0.63fF
C1961 la_data_out[89] vssa1 0.63fF
C1962 la_data_in[89] vssa1 0.63fF
C1963 la_oenb[88] vssa1 0.63fF
C1964 la_data_out[88] vssa1 0.63fF
C1965 la_data_in[88] vssa1 0.63fF
C1966 la_oenb[87] vssa1 0.63fF
C1967 la_data_out[87] vssa1 0.63fF
C1968 la_data_in[87] vssa1 0.63fF
C1969 la_oenb[86] vssa1 0.63fF
C1970 la_data_out[86] vssa1 0.63fF
C1971 la_data_in[86] vssa1 0.63fF
C1972 la_oenb[85] vssa1 0.63fF
C1973 la_data_out[85] vssa1 0.63fF
C1974 la_data_in[85] vssa1 0.63fF
C1975 la_oenb[84] vssa1 0.63fF
C1976 la_data_out[84] vssa1 0.63fF
C1977 la_data_in[84] vssa1 0.63fF
C1978 la_oenb[83] vssa1 0.63fF
C1979 la_data_out[83] vssa1 0.63fF
C1980 la_data_in[83] vssa1 0.63fF
C1981 la_oenb[82] vssa1 0.63fF
C1982 la_data_out[82] vssa1 0.63fF
C1983 la_data_in[82] vssa1 0.63fF
C1984 la_oenb[81] vssa1 0.63fF
C1985 la_data_out[81] vssa1 0.63fF
C1986 la_data_in[81] vssa1 0.63fF
C1987 la_oenb[80] vssa1 0.63fF
C1988 la_data_out[80] vssa1 0.63fF
C1989 la_data_in[80] vssa1 0.63fF
C1990 la_oenb[79] vssa1 0.63fF
C1991 la_data_out[79] vssa1 0.63fF
C1992 la_data_in[79] vssa1 0.63fF
C1993 la_oenb[78] vssa1 0.63fF
C1994 la_data_out[78] vssa1 0.63fF
C1995 la_data_in[78] vssa1 0.63fF
C1996 la_oenb[77] vssa1 0.63fF
C1997 la_data_out[77] vssa1 0.63fF
C1998 la_data_in[77] vssa1 0.63fF
C1999 la_oenb[76] vssa1 0.63fF
C2000 la_data_out[76] vssa1 0.63fF
C2001 la_data_in[76] vssa1 0.63fF
C2002 la_oenb[75] vssa1 0.63fF
C2003 la_data_out[75] vssa1 0.63fF
C2004 la_data_in[75] vssa1 0.63fF
C2005 la_oenb[74] vssa1 0.63fF
C2006 la_data_out[74] vssa1 0.63fF
C2007 la_data_in[74] vssa1 0.63fF
C2008 la_oenb[73] vssa1 0.63fF
C2009 la_data_out[73] vssa1 0.63fF
C2010 la_data_in[73] vssa1 0.63fF
C2011 la_oenb[72] vssa1 0.63fF
C2012 la_data_out[72] vssa1 0.63fF
C2013 la_data_in[72] vssa1 0.63fF
C2014 la_oenb[71] vssa1 0.63fF
C2015 la_data_out[71] vssa1 0.63fF
C2016 la_data_in[71] vssa1 0.63fF
C2017 la_oenb[70] vssa1 0.63fF
C2018 la_data_out[70] vssa1 0.63fF
C2019 la_data_in[70] vssa1 0.63fF
C2020 la_oenb[69] vssa1 0.63fF
C2021 la_data_out[69] vssa1 0.63fF
C2022 la_data_in[69] vssa1 0.63fF
C2023 la_oenb[68] vssa1 0.63fF
C2024 la_data_out[68] vssa1 0.63fF
C2025 la_data_in[68] vssa1 0.63fF
C2026 la_oenb[67] vssa1 0.63fF
C2027 la_data_out[67] vssa1 0.63fF
C2028 la_data_in[67] vssa1 0.63fF
C2029 la_oenb[66] vssa1 0.63fF
C2030 la_data_out[66] vssa1 0.63fF
C2031 la_data_in[66] vssa1 0.63fF
C2032 la_oenb[65] vssa1 0.63fF
C2033 la_data_out[65] vssa1 0.63fF
C2034 la_data_in[65] vssa1 0.63fF
C2035 la_oenb[64] vssa1 0.63fF
C2036 la_data_out[64] vssa1 0.63fF
C2037 la_data_in[64] vssa1 0.63fF
C2038 la_oenb[63] vssa1 0.63fF
C2039 la_data_out[63] vssa1 0.63fF
C2040 la_data_in[63] vssa1 0.63fF
C2041 la_oenb[62] vssa1 0.63fF
C2042 la_data_out[62] vssa1 0.63fF
C2043 la_data_in[62] vssa1 0.63fF
C2044 la_oenb[61] vssa1 0.63fF
C2045 la_data_out[61] vssa1 0.63fF
C2046 la_data_in[61] vssa1 0.63fF
C2047 la_oenb[60] vssa1 0.63fF
C2048 la_data_out[60] vssa1 0.63fF
C2049 la_data_in[60] vssa1 0.63fF
C2050 la_oenb[59] vssa1 0.63fF
C2051 la_data_out[59] vssa1 0.63fF
C2052 la_data_in[59] vssa1 0.63fF
C2053 la_oenb[58] vssa1 0.63fF
C2054 la_data_out[58] vssa1 0.63fF
C2055 la_data_in[58] vssa1 0.63fF
C2056 la_oenb[57] vssa1 0.63fF
C2057 la_data_out[57] vssa1 0.63fF
C2058 la_data_in[57] vssa1 0.63fF
C2059 la_oenb[56] vssa1 0.63fF
C2060 la_data_out[56] vssa1 0.63fF
C2061 la_data_in[56] vssa1 0.63fF
C2062 la_oenb[55] vssa1 0.63fF
C2063 la_data_out[55] vssa1 0.63fF
C2064 la_data_in[55] vssa1 0.63fF
C2065 la_oenb[54] vssa1 0.63fF
C2066 la_data_out[54] vssa1 0.63fF
C2067 la_data_in[54] vssa1 0.63fF
C2068 la_oenb[53] vssa1 0.63fF
C2069 la_data_out[53] vssa1 0.63fF
C2070 la_data_in[53] vssa1 0.63fF
C2071 la_oenb[52] vssa1 0.63fF
C2072 la_data_out[52] vssa1 0.63fF
C2073 la_data_in[52] vssa1 0.63fF
C2074 la_oenb[51] vssa1 0.63fF
C2075 la_data_out[51] vssa1 0.63fF
C2076 la_data_in[51] vssa1 0.63fF
C2077 la_oenb[50] vssa1 0.63fF
C2078 la_data_out[50] vssa1 0.63fF
C2079 la_data_in[50] vssa1 0.63fF
C2080 la_oenb[49] vssa1 0.63fF
C2081 la_data_out[49] vssa1 0.63fF
C2082 la_data_in[49] vssa1 0.63fF
C2083 la_oenb[48] vssa1 0.63fF
C2084 la_data_out[48] vssa1 0.63fF
C2085 la_data_in[48] vssa1 0.63fF
C2086 la_oenb[47] vssa1 0.63fF
C2087 la_data_out[47] vssa1 0.63fF
C2088 la_data_in[47] vssa1 0.63fF
C2089 la_oenb[46] vssa1 0.63fF
C2090 la_data_out[46] vssa1 0.63fF
C2091 la_data_in[46] vssa1 0.63fF
C2092 la_oenb[45] vssa1 0.63fF
C2093 la_data_out[45] vssa1 0.63fF
C2094 la_data_in[45] vssa1 0.63fF
C2095 la_oenb[44] vssa1 0.63fF
C2096 la_data_out[44] vssa1 0.63fF
C2097 la_data_in[44] vssa1 0.63fF
C2098 la_oenb[43] vssa1 0.63fF
C2099 la_data_out[43] vssa1 0.63fF
C2100 la_data_in[43] vssa1 0.63fF
C2101 la_oenb[42] vssa1 0.63fF
C2102 la_data_out[42] vssa1 0.63fF
C2103 la_data_in[42] vssa1 0.63fF
C2104 la_oenb[41] vssa1 0.63fF
C2105 la_data_out[41] vssa1 0.63fF
C2106 la_data_in[41] vssa1 0.63fF
C2107 la_oenb[40] vssa1 0.63fF
C2108 la_data_out[40] vssa1 0.63fF
C2109 la_data_in[40] vssa1 0.63fF
C2110 la_oenb[39] vssa1 0.63fF
C2111 la_data_out[39] vssa1 0.63fF
C2112 la_data_in[39] vssa1 0.63fF
C2113 la_oenb[38] vssa1 0.63fF
C2114 la_data_out[38] vssa1 0.63fF
C2115 la_data_in[38] vssa1 0.63fF
C2116 la_oenb[37] vssa1 0.63fF
C2117 la_data_out[37] vssa1 0.63fF
C2118 la_data_in[37] vssa1 0.63fF
C2119 la_oenb[36] vssa1 0.63fF
C2120 la_data_out[36] vssa1 0.63fF
C2121 la_data_in[36] vssa1 0.63fF
C2122 la_oenb[35] vssa1 0.63fF
C2123 la_data_out[35] vssa1 0.63fF
C2124 la_data_in[35] vssa1 0.63fF
C2125 la_oenb[34] vssa1 0.63fF
C2126 la_data_out[34] vssa1 0.63fF
C2127 la_data_in[34] vssa1 0.63fF
C2128 la_oenb[33] vssa1 0.63fF
C2129 la_data_out[33] vssa1 0.63fF
C2130 la_data_in[33] vssa1 0.63fF
C2131 la_oenb[32] vssa1 0.63fF
C2132 la_data_out[32] vssa1 0.63fF
C2133 la_data_in[32] vssa1 0.63fF
C2134 la_oenb[31] vssa1 0.63fF
C2135 la_data_out[31] vssa1 0.63fF
C2136 la_data_in[31] vssa1 0.63fF
C2137 la_oenb[30] vssa1 0.63fF
C2138 la_data_out[30] vssa1 0.63fF
C2139 la_data_in[30] vssa1 0.63fF
C2140 la_oenb[29] vssa1 0.63fF
C2141 la_data_out[29] vssa1 0.63fF
C2142 la_data_in[29] vssa1 0.63fF
C2143 la_oenb[28] vssa1 0.63fF
C2144 la_data_out[28] vssa1 0.63fF
C2145 la_data_in[28] vssa1 0.63fF
C2146 la_oenb[27] vssa1 0.63fF
C2147 la_data_out[27] vssa1 0.63fF
C2148 la_data_in[27] vssa1 0.63fF
C2149 la_oenb[26] vssa1 0.63fF
C2150 la_data_out[26] vssa1 0.63fF
C2151 la_data_in[26] vssa1 0.63fF
C2152 la_oenb[25] vssa1 0.63fF
C2153 la_data_out[25] vssa1 0.63fF
C2154 la_data_in[25] vssa1 0.63fF
C2155 la_oenb[24] vssa1 0.63fF
C2156 la_data_out[24] vssa1 0.63fF
C2157 la_data_in[24] vssa1 0.63fF
C2158 la_oenb[23] vssa1 0.63fF
C2159 la_data_out[23] vssa1 0.63fF
C2160 la_data_in[23] vssa1 0.63fF
C2161 la_oenb[22] vssa1 0.63fF
C2162 la_data_out[22] vssa1 0.63fF
C2163 la_data_in[22] vssa1 0.63fF
C2164 la_oenb[21] vssa1 0.63fF
C2165 la_data_out[21] vssa1 0.63fF
C2166 la_data_in[21] vssa1 0.63fF
C2167 la_oenb[20] vssa1 0.63fF
C2168 la_data_out[20] vssa1 0.63fF
C2169 la_data_in[20] vssa1 0.63fF
C2170 la_oenb[19] vssa1 0.63fF
C2171 la_data_out[19] vssa1 0.63fF
C2172 la_data_in[19] vssa1 0.63fF
C2173 la_oenb[18] vssa1 0.63fF
C2174 la_data_out[18] vssa1 0.63fF
C2175 la_data_in[18] vssa1 0.63fF
C2176 la_oenb[17] vssa1 0.63fF
C2177 la_data_out[17] vssa1 0.63fF
C2178 la_data_in[17] vssa1 0.63fF
C2179 la_oenb[16] vssa1 0.63fF
C2180 la_data_out[16] vssa1 0.63fF
C2181 la_data_in[16] vssa1 0.63fF
C2182 la_oenb[15] vssa1 0.63fF
C2183 la_data_out[15] vssa1 0.63fF
C2184 la_data_in[15] vssa1 0.63fF
C2185 la_oenb[14] vssa1 0.63fF
C2186 la_data_out[14] vssa1 0.63fF
C2187 la_data_in[14] vssa1 0.63fF
C2188 la_oenb[13] vssa1 0.63fF
C2189 la_data_out[13] vssa1 0.63fF
C2190 la_data_in[13] vssa1 0.63fF
C2191 la_oenb[12] vssa1 0.63fF
C2192 la_data_out[12] vssa1 0.63fF
C2193 la_data_in[12] vssa1 0.63fF
C2194 la_oenb[11] vssa1 0.63fF
C2195 la_data_out[11] vssa1 0.63fF
C2196 la_data_in[11] vssa1 0.63fF
C2197 la_oenb[10] vssa1 0.63fF
C2198 la_data_out[10] vssa1 0.63fF
C2199 la_data_in[10] vssa1 0.63fF
C2200 la_oenb[9] vssa1 0.63fF
C2201 la_data_out[9] vssa1 0.63fF
C2202 la_data_in[9] vssa1 0.63fF
C2203 la_oenb[8] vssa1 0.63fF
C2204 la_data_out[8] vssa1 0.63fF
C2205 la_data_in[8] vssa1 0.63fF
C2206 la_oenb[7] vssa1 0.63fF
C2207 la_data_out[7] vssa1 0.63fF
C2208 la_data_in[7] vssa1 0.63fF
C2209 la_oenb[6] vssa1 0.63fF
C2210 la_data_out[6] vssa1 0.63fF
C2211 la_data_in[6] vssa1 0.63fF
C2212 la_oenb[5] vssa1 0.63fF
C2213 la_data_out[5] vssa1 0.63fF
C2214 la_data_in[5] vssa1 0.63fF
C2215 la_oenb[4] vssa1 0.63fF
C2216 la_data_out[4] vssa1 0.63fF
C2217 la_data_in[4] vssa1 0.63fF
C2218 la_oenb[3] vssa1 0.63fF
C2219 la_data_out[3] vssa1 0.63fF
C2220 la_data_in[3] vssa1 0.63fF
C2221 la_oenb[2] vssa1 0.63fF
C2222 la_data_out[2] vssa1 0.63fF
C2223 la_data_in[2] vssa1 0.63fF
C2224 la_oenb[1] vssa1 0.63fF
C2225 la_data_out[1] vssa1 0.63fF
C2226 la_data_in[1] vssa1 0.63fF
C2227 la_oenb[0] vssa1 0.63fF
C2228 la_data_out[0] vssa1 0.63fF
C2229 la_data_in[0] vssa1 0.63fF
C2230 wbs_dat_o[31] vssa1 0.63fF
C2231 wbs_dat_i[31] vssa1 0.63fF
C2232 wbs_adr_i[31] vssa1 0.63fF
C2233 wbs_dat_o[30] vssa1 0.63fF
C2234 wbs_dat_i[30] vssa1 0.63fF
C2235 wbs_adr_i[30] vssa1 0.63fF
C2236 wbs_dat_o[29] vssa1 0.63fF
C2237 wbs_dat_i[29] vssa1 0.63fF
C2238 wbs_adr_i[29] vssa1 0.63fF
C2239 wbs_dat_o[28] vssa1 0.63fF
C2240 wbs_dat_i[28] vssa1 0.63fF
C2241 wbs_adr_i[28] vssa1 0.63fF
C2242 wbs_dat_o[27] vssa1 0.63fF
C2243 wbs_dat_i[27] vssa1 0.63fF
C2244 wbs_adr_i[27] vssa1 0.63fF
C2245 wbs_dat_o[26] vssa1 0.63fF
C2246 wbs_dat_i[26] vssa1 0.63fF
C2247 wbs_adr_i[26] vssa1 0.63fF
C2248 wbs_dat_o[25] vssa1 0.63fF
C2249 wbs_dat_i[25] vssa1 0.63fF
C2250 wbs_adr_i[25] vssa1 0.63fF
C2251 wbs_dat_o[24] vssa1 0.63fF
C2252 wbs_dat_i[24] vssa1 0.63fF
C2253 wbs_adr_i[24] vssa1 0.63fF
C2254 wbs_dat_o[23] vssa1 0.63fF
C2255 wbs_dat_i[23] vssa1 0.63fF
C2256 wbs_adr_i[23] vssa1 0.63fF
C2257 wbs_dat_o[22] vssa1 0.63fF
C2258 wbs_dat_i[22] vssa1 0.63fF
C2259 wbs_adr_i[22] vssa1 0.63fF
C2260 wbs_dat_o[21] vssa1 0.63fF
C2261 wbs_dat_i[21] vssa1 0.63fF
C2262 wbs_adr_i[21] vssa1 0.63fF
C2263 wbs_dat_o[20] vssa1 0.63fF
C2264 wbs_dat_i[20] vssa1 0.63fF
C2265 wbs_adr_i[20] vssa1 0.63fF
C2266 wbs_dat_o[19] vssa1 0.63fF
C2267 wbs_dat_i[19] vssa1 0.63fF
C2268 wbs_adr_i[19] vssa1 0.63fF
C2269 wbs_dat_o[18] vssa1 0.63fF
C2270 wbs_dat_i[18] vssa1 0.63fF
C2271 wbs_adr_i[18] vssa1 0.63fF
C2272 wbs_dat_o[17] vssa1 0.63fF
C2273 wbs_dat_i[17] vssa1 0.63fF
C2274 wbs_adr_i[17] vssa1 0.63fF
C2275 wbs_dat_o[16] vssa1 0.63fF
C2276 wbs_dat_i[16] vssa1 0.63fF
C2277 wbs_adr_i[16] vssa1 0.63fF
C2278 wbs_dat_o[15] vssa1 0.63fF
C2279 wbs_dat_i[15] vssa1 0.63fF
C2280 wbs_adr_i[15] vssa1 0.63fF
C2281 wbs_dat_o[14] vssa1 0.63fF
C2282 wbs_dat_i[14] vssa1 0.63fF
C2283 wbs_adr_i[14] vssa1 0.63fF
C2284 wbs_dat_o[13] vssa1 0.63fF
C2285 wbs_dat_i[13] vssa1 0.63fF
C2286 wbs_adr_i[13] vssa1 0.63fF
C2287 wbs_dat_o[12] vssa1 0.63fF
C2288 wbs_dat_i[12] vssa1 0.63fF
C2289 wbs_adr_i[12] vssa1 0.63fF
C2290 wbs_dat_o[11] vssa1 0.63fF
C2291 wbs_dat_i[11] vssa1 0.63fF
C2292 wbs_adr_i[11] vssa1 0.63fF
C2293 wbs_dat_o[10] vssa1 0.63fF
C2294 wbs_dat_i[10] vssa1 0.63fF
C2295 wbs_adr_i[10] vssa1 0.63fF
C2296 wbs_dat_o[9] vssa1 0.63fF
C2297 wbs_dat_i[9] vssa1 0.63fF
C2298 wbs_adr_i[9] vssa1 0.63fF
C2299 wbs_dat_o[8] vssa1 0.63fF
C2300 wbs_dat_i[8] vssa1 0.63fF
C2301 wbs_adr_i[8] vssa1 0.63fF
C2302 wbs_dat_o[7] vssa1 0.63fF
C2303 wbs_dat_i[7] vssa1 0.63fF
C2304 wbs_adr_i[7] vssa1 0.63fF
C2305 wbs_dat_o[6] vssa1 0.63fF
C2306 wbs_dat_i[6] vssa1 0.63fF
C2307 wbs_adr_i[6] vssa1 0.63fF
C2308 wbs_dat_o[5] vssa1 0.63fF
C2309 wbs_dat_i[5] vssa1 0.63fF
C2310 wbs_adr_i[5] vssa1 0.63fF
C2311 wbs_dat_o[4] vssa1 0.63fF
C2312 wbs_dat_i[4] vssa1 0.63fF
C2313 wbs_adr_i[4] vssa1 0.63fF
C2314 wbs_sel_i[3] vssa1 0.63fF
C2315 wbs_dat_o[3] vssa1 0.63fF
C2316 wbs_dat_i[3] vssa1 0.63fF
C2317 wbs_adr_i[3] vssa1 0.63fF
C2318 wbs_sel_i[2] vssa1 0.63fF
C2319 wbs_dat_o[2] vssa1 0.63fF
C2320 wbs_dat_i[2] vssa1 0.63fF
C2321 wbs_adr_i[2] vssa1 0.63fF
C2322 wbs_sel_i[1] vssa1 0.63fF
C2323 wbs_dat_o[1] vssa1 0.63fF
C2324 wbs_dat_i[1] vssa1 0.63fF
C2325 wbs_adr_i[1] vssa1 0.63fF
C2326 wbs_sel_i[0] vssa1 0.63fF
C2327 wbs_dat_o[0] vssa1 0.63fF
C2328 wbs_dat_i[0] vssa1 0.63fF
C2329 wbs_adr_i[0] vssa1 0.63fF
C2330 wbs_we_i vssa1 0.63fF
C2331 wbs_stb_i vssa1 0.63fF
C2332 wbs_cyc_i vssa1 0.63fF
C2333 wbs_ack_o vssa1 0.63fF
C2334 wb_rst_i vssa1 0.63fF
C2335 wb_clk_i vssa1 0.63fF
C2336 m2_494098_659718# vssa1 0.80fF **FLOATING
C2337 pll_full_1/divider_0/and_0/Z1 vssa1 0.65fF
C2338 pll_full_1/divider_0/and_0/B vssa1 2.45fF
C2339 pll_full_1/divider_0/and_0/A vssa1 2.35fF
C2340 pll_full_1/divider_0/and_0/out1 vssa1 2.99fF
C2341 pll_full_1/divider_0/tspc_2/Z4 vssa1 0.86fF
C2342 pll_full_1/divider_0/tspc_2/Z3 vssa1 2.26fF
C2343 pll_full_1/divider_0/tspc_2/Z2 vssa1 1.46fF
C2344 pll_full_1/divider_0/tspc_2/Z1 vssa1 0.99fF
C2345 pll_full_1/divider_0/nor_0/A vssa1 7.08fF
C2346 pll_full_1/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2347 pll_full_1/divider_0/tspc_1/Z4 vssa1 0.86fF
C2348 pll_full_1/divider_0/tspc_1/Z3 vssa1 2.26fF
C2349 pll_full_1/divider_0/tspc_1/Z2 vssa1 1.46fF
C2350 pll_full_1/divider_0/tspc_1/Z1 vssa1 0.99fF
C2351 pll_full_1/divider_0/nor_0/B vssa1 7.12fF
C2352 pll_full_1/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2353 pll_full_1/divider_0/tspc_2/Q vssa1 3.14fF
C2354 pll_full_1/divider_0/tspc_0/Z4 vssa1 0.86fF
C2355 pll_full_1/divbuf_0/IN vssa1 9.89fF
C2356 pll_full_1/divider_0/tspc_0/Z3 vssa1 2.26fF
C2357 pll_full_1/divider_0/tspc_0/Z2 vssa1 1.46fF
C2358 pll_full_1/divider_0/tspc_0/Z1 vssa1 0.99fF
C2359 pll_full_1/divider_0/nor_1/B vssa1 6.48fF
C2360 pll_full_1/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2361 pll_full_1/divider_0/tspc_1/Q vssa1 3.12fF
C2362 pll_full_1/divider_0/clk vssa1 33.42fF
C2363 pll_full_1/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2364 pll_full_1/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2365 pll_full_1/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2366 pll_full_1/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2367 pll_full_1/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2368 pll_full_1/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2369 pll_full_1/divider_0/and_0/OUT vssa1 5.67fF
C2370 pll_full_1/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2371 pll_full_1/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2372 pll_full_1/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2373 pll_full_1/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2374 pll_full_1/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2375 pll_full_1/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2376 pll_full_1/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2377 pll_full_1/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2378 pll_full_1/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2379 pll_full_1/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2380 pll_full_1/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2381 pll_full_1/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2382 pll_full_1/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2383 pll_full_1/divider_0/prescaler_0/Out vssa1 4.59fF
C2384 pll_full_1/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2385 pll_full_1/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2386 pll_full_1/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2387 pll_full_1/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2388 pll_full_1/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2389 pll_full_1/divider_0/nor_1/Z1 vssa1 1.34fF
C2390 pll_full_1/divider_0/nor_0/Z1 vssa1 1.34fF
C2391 pll_full_1/divbuf_1/OUT vssa1 363.82fF
C2392 pll_full_1/divbuf_1/OUT5 vssa1 350.37fF
C2393 pll_full_1/divbuf_1/OUT4 vssa1 133.72fF
C2394 pll_full_1/divbuf_1/OUT3 vssa1 34.03fF
C2395 pll_full_1/divbuf_1/OUT2 vssa1 8.71fF
C2396 pll_full_1/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2397 pll_full_1/divbuf_0/OUT5 vssa1 350.37fF
C2398 pll_full_1/divbuf_0/OUT4 vssa1 133.72fF
C2399 pll_full_1/divbuf_0/OUT3 vssa1 34.03fF
C2400 pll_full_1/divbuf_0/OUT2 vssa1 8.71fF
C2401 pll_full_1/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2402 pll_full_1/ro_complete_0/cbank_2/v vssa1 16.43fF
C2403 pll_full_1/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2404 pll_full_1/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2405 pll_full_1/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2406 pll_full_1/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2407 pll_full_1/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2408 pll_full_1/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2409 pll_full_1/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2410 pll_full_1/ro_complete_0/a0 vssa1 5.35fF
C2411 pll_full_1/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2412 pll_full_1/ro_complete_0/a1 vssa1 6.54fF
C2413 pll_full_1/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2414 pll_full_1/ro_complete_0/a3 vssa1 5.96fF
C2415 pll_full_1/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2416 pll_full_1/ro_complete_0/a2 vssa1 5.21fF
C2417 pll_full_1/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2418 pll_full_1/ro_complete_0/a4 vssa1 5.81fF
C2419 pll_full_1/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2420 pll_full_1/ro_complete_0/a5 vssa1 6.74fF
C2421 pll_full_1/ro_complete_0/cbank_0/v vssa1 15.12fF
C2422 pll_full_1/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2423 pll_full_1/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2424 pll_full_1/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2425 pll_full_1/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2426 pll_full_1/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2427 pll_full_1/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2428 pll_full_1/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2429 pll_full_1/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2430 pll_full_1/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2431 pll_full_1/cp_0/down vssa1 1.54fF
C2432 pll_full_1/cp_0/upbar vssa1 1.79fF
C2433 pll_full_1/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2434 pll_full_1/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2435 pll_full_1/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2436 pll_full_1/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2437 pll_full_1/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2438 pll_full_1/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2439 pll_full_1/pd_0/UP vssa1 6.41fF
C2440 pll_full_1/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2441 pll_full_1/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2442 pll_full_1/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2443 pll_full_1/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2444 pll_full_1/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2445 pll_full_1/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2446 pll_full_1/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2447 pll_full_1/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2448 pll_full_1/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2449 pll_full_1/pd_0/REF vssa1 6.48fF
C2450 pll_full_1/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2451 pll_full_1/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2452 pll_full_1/pd_0/R vssa1 3.05fF
C2453 pll_full_1/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2454 pll_full_1/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2455 pll_full_1/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2456 pll_full_1/pd_0/DOWN vssa1 7.34fF
C2457 pll_full_1/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2458 pll_full_1/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2459 pll_full_1/pd_0/DIV vssa1 372.69fF
C2460 pll_full_0/divider_0/and_0/Z1 vssa1 0.65fF
C2461 pll_full_0/divider_0/and_0/B vssa1 2.45fF
C2462 pll_full_0/divider_0/and_0/A vssa1 2.35fF
C2463 pll_full_0/divider_0/and_0/out1 vssa1 2.99fF
C2464 pll_full_0/divider_0/tspc_2/Z4 vssa1 0.86fF
C2465 pll_full_0/divider_0/tspc_2/Z3 vssa1 2.26fF
C2466 pll_full_0/divider_0/tspc_2/Z2 vssa1 1.46fF
C2467 pll_full_0/divider_0/tspc_2/Z1 vssa1 0.99fF
C2468 pll_full_0/divider_0/nor_0/A vssa1 7.08fF
C2469 pll_full_0/divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2470 pll_full_0/divider_0/tspc_1/Z4 vssa1 0.86fF
C2471 pll_full_0/divider_0/tspc_1/Z3 vssa1 2.26fF
C2472 pll_full_0/divider_0/tspc_1/Z2 vssa1 1.46fF
C2473 pll_full_0/divider_0/tspc_1/Z1 vssa1 0.99fF
C2474 pll_full_0/divider_0/nor_0/B vssa1 7.12fF
C2475 pll_full_0/divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2476 pll_full_0/divider_0/tspc_2/Q vssa1 3.14fF
C2477 pll_full_0/divider_0/tspc_0/Z4 vssa1 0.86fF
C2478 pll_full_0/divbuf_0/IN vssa1 9.89fF
C2479 pll_full_0/divider_0/tspc_0/Z3 vssa1 2.26fF
C2480 pll_full_0/divider_0/tspc_0/Z2 vssa1 1.46fF
C2481 pll_full_0/divider_0/tspc_0/Z1 vssa1 0.99fF
C2482 pll_full_0/divider_0/nor_1/B vssa1 6.48fF
C2483 pll_full_0/divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2484 pll_full_0/divider_0/tspc_1/Q vssa1 3.12fF
C2485 pll_full_0/divider_0/clk vssa1 33.42fF
C2486 pll_full_0/divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2487 pll_full_0/divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2488 pll_full_0/divider_0/prescaler_0/tspc_2/Q vssa1 3.72fF
C2489 pll_full_0/divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2490 pll_full_0/divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2491 pll_full_0/divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2492 pll_full_0/divider_0/and_0/OUT vssa1 5.67fF
C2493 pll_full_0/divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2494 pll_full_0/divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2495 pll_full_0/divider_0/prescaler_0/tspc_2/Z2 vssa1 1.19fF
C2496 pll_full_0/divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2497 pll_full_0/divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.47fF **FLOATING
C2498 pll_full_0/divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2499 pll_full_0/divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2500 pll_full_0/divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2501 pll_full_0/divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2502 pll_full_0/divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2503 pll_full_0/divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2504 pll_full_0/divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2505 pll_full_0/divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2506 pll_full_0/divider_0/prescaler_0/Out vssa1 4.59fF
C2507 pll_full_0/divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2508 pll_full_0/divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2509 pll_full_0/divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2510 pll_full_0/divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2511 pll_full_0/divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2512 pll_full_0/divider_0/nor_1/Z1 vssa1 1.34fF
C2513 pll_full_0/divider_0/nor_0/Z1 vssa1 1.34fF
C2514 pll_full_0/divbuf_1/OUT vssa1 363.82fF
C2515 pll_full_0/divbuf_1/OUT5 vssa1 350.37fF
C2516 pll_full_0/divbuf_1/OUT4 vssa1 133.72fF
C2517 pll_full_0/divbuf_1/OUT3 vssa1 34.03fF
C2518 pll_full_0/divbuf_1/OUT2 vssa1 8.71fF
C2519 pll_full_0/divbuf_1/a_492_n240# vssa1 2.46fF **FLOATING
C2520 pll_full_0/divbuf_0/OUT5 vssa1 350.37fF
C2521 pll_full_0/divbuf_0/OUT4 vssa1 133.72fF
C2522 pll_full_0/divbuf_0/OUT3 vssa1 34.03fF
C2523 pll_full_0/divbuf_0/OUT2 vssa1 8.71fF
C2524 pll_full_0/divbuf_0/a_492_n240# vssa1 2.46fF **FLOATING
C2525 pll_full_0/ro_complete_0/cbank_2/v vssa1 16.43fF
C2526 pll_full_0/ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2527 pll_full_0/ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2528 pll_full_0/ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2529 pll_full_0/ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2530 pll_full_0/ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2531 pll_full_0/ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2532 pll_full_0/ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2533 pll_full_0/ro_complete_0/a0 vssa1 5.35fF
C2534 pll_full_0/ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2535 pll_full_0/ro_complete_0/a1 vssa1 6.54fF
C2536 pll_full_0/ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2537 pll_full_0/ro_complete_0/a3 vssa1 5.96fF
C2538 pll_full_0/ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2539 pll_full_0/ro_complete_0/a2 vssa1 5.21fF
C2540 pll_full_0/ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2541 pll_full_0/ro_complete_0/a4 vssa1 5.81fF
C2542 pll_full_0/ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2543 pll_full_0/ro_complete_0/a5 vssa1 6.74fF
C2544 pll_full_0/ro_complete_0/cbank_0/v vssa1 15.12fF
C2545 pll_full_0/ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2546 pll_full_0/ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2547 pll_full_0/ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2548 pll_full_0/ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2549 pll_full_0/ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2550 pll_full_0/ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2551 pll_full_0/ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2552 pll_full_0/filter_0/a_4216_n5230# vssa1 418.90fF **FLOATING
C2553 pll_full_0/filter_0/a_4216_n2998# vssa1 1.39fF **FLOATING
C2554 pll_full_0/cp_0/down vssa1 1.54fF
C2555 pll_full_0/cp_0/upbar vssa1 1.79fF
C2556 pll_full_0/cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2557 pll_full_0/cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2558 pll_full_0/cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2559 pll_full_0/cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2560 pll_full_0/cp_0/a_3060_0# vssa1 2.49fF **FLOATING
C2561 pll_full_0/cp_0/a_1710_0# vssa1 7.47fF **FLOATING
C2562 pll_full_0/pd_0/UP vssa1 6.41fF
C2563 pll_full_0/pd_0/and_pd_0/Z1 vssa1 0.39fF
C2564 pll_full_0/pd_0/and_pd_0/Out1 vssa1 2.22fF
C2565 pll_full_0/pd_0/tspc_r_1/z5 vssa1 1.10fF
C2566 pll_full_0/pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2567 pll_full_0/pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2568 pll_full_0/pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2569 pll_full_0/pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2570 pll_full_0/pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2571 pll_full_0/pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2572 pll_full_0/pd_0/REF vssa1 6.48fF
C2573 pll_full_0/pd_0/tspc_r_0/z5 vssa1 1.10fF
C2574 pll_full_0/pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2575 pll_full_0/pd_0/R vssa1 3.05fF
C2576 pll_full_0/pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2577 pll_full_0/pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2578 pll_full_0/pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2579 pll_full_0/pd_0/DOWN vssa1 7.34fF
C2580 pll_full_0/pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2581 pll_full_0/pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2582 pll_full_0/pd_0/DIV vssa1 372.69fF
C2583 divider_2/and_0/Z1 vssa1 0.74fF
C2584 divider_2/and_0/B vssa1 2.25fF
C2585 divider_2/and_0/A vssa1 2.19fF
C2586 divider_2/and_0/out1 vssa1 2.93fF
C2587 divider_2/tspc_2/Z4 vssa1 0.86fF
C2588 divider_2/tspc_2/Z3 vssa1 2.26fF
C2589 divider_2/tspc_2/Z2 vssa1 1.46fF
C2590 divider_2/tspc_2/Z1 vssa1 0.99fF
C2591 divider_2/nor_0/A vssa1 7.04fF
C2592 divider_2/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2593 divider_2/tspc_1/Z4 vssa1 0.86fF
C2594 divider_2/tspc_1/Z3 vssa1 2.26fF
C2595 divider_2/tspc_1/Z2 vssa1 1.46fF
C2596 divider_2/tspc_1/Z1 vssa1 0.99fF
C2597 divider_2/nor_0/B vssa1 7.05fF
C2598 divider_2/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2599 divider_2/tspc_2/Q vssa1 3.14fF
C2600 divider_2/tspc_0/Z4 vssa1 0.86fF
C2601 divider_2/Out vssa1 1.60fF
C2602 divider_2/tspc_0/Z3 vssa1 2.26fF
C2603 divider_2/tspc_0/Z2 vssa1 1.46fF
C2604 divider_2/tspc_0/Z1 vssa1 0.99fF
C2605 divider_2/nor_1/B vssa1 6.44fF
C2606 divider_2/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2607 divider_2/tspc_1/Q vssa1 3.12fF
C2608 divider_2/clk vssa1 5.63fF
C2609 divider_2/prescaler_0/nand_1/z1 vssa1 0.36fF
C2610 divider_2/prescaler_0/tspc_0/D vssa1 2.64fF
C2611 divider_2/prescaler_0/tspc_2/Q vssa1 3.74fF
C2612 divider_2/prescaler_0/tspc_1/Q vssa1 3.61fF
C2613 divider_2/prescaler_0/nand_0/z1 vssa1 0.36fF
C2614 divider_2/prescaler_0/tspc_2/D vssa1 3.12fF
C2615 divider_2/and_0/OUT vssa1 5.62fF
C2616 divider_2/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2617 divider_2/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2618 divider_2/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C2619 divider_2/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2620 divider_2/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2621 divider_2/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2622 divider_2/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2623 divider_2/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2624 divider_2/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2625 divider_2/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2626 divider_2/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2627 divider_2/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2628 divider_2/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2629 divider_2/prescaler_0/Out vssa1 4.59fF
C2630 divider_2/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2631 divider_2/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2632 divider_2/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2633 divider_2/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2634 divider_2/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2635 divider_2/nor_1/Z1 vssa1 1.34fF
C2636 divider_2/mc2 vssa1 5.29fF
C2637 divider_2/nor_0/Z1 vssa1 1.34fF
C2638 divider_1/and_0/Z1 vssa1 0.74fF
C2639 divider_1/and_0/B vssa1 2.25fF
C2640 divider_1/and_0/A vssa1 2.19fF
C2641 divider_1/and_0/out1 vssa1 2.93fF
C2642 divider_1/tspc_2/Z4 vssa1 0.86fF
C2643 divider_1/tspc_2/Z3 vssa1 2.26fF
C2644 divider_1/tspc_2/Z2 vssa1 1.46fF
C2645 divider_1/tspc_2/Z1 vssa1 0.99fF
C2646 divider_1/nor_0/A vssa1 7.04fF
C2647 divider_1/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2648 divider_1/tspc_1/Z4 vssa1 0.86fF
C2649 divider_1/tspc_1/Z3 vssa1 2.26fF
C2650 divider_1/tspc_1/Z2 vssa1 1.46fF
C2651 divider_1/tspc_1/Z1 vssa1 0.99fF
C2652 divider_1/nor_0/B vssa1 7.05fF
C2653 divider_1/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2654 divider_1/tspc_2/Q vssa1 3.14fF
C2655 divider_1/tspc_0/Z4 vssa1 0.86fF
C2656 divider_1/Out vssa1 1.60fF
C2657 divider_1/tspc_0/Z3 vssa1 2.26fF
C2658 divider_1/tspc_0/Z2 vssa1 1.46fF
C2659 divider_1/tspc_0/Z1 vssa1 0.99fF
C2660 divider_1/nor_1/B vssa1 6.33fF
C2661 divider_1/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2662 divider_1/tspc_1/Q vssa1 3.12fF
C2663 divider_1/clk vssa1 5.63fF
C2664 divider_1/prescaler_0/nand_1/z1 vssa1 0.36fF
C2665 divider_1/prescaler_0/tspc_0/D vssa1 2.64fF
C2666 divider_1/prescaler_0/tspc_2/Q vssa1 3.74fF
C2667 divider_1/prescaler_0/tspc_1/Q vssa1 3.61fF
C2668 divider_1/prescaler_0/nand_0/z1 vssa1 0.36fF
C2669 divider_1/prescaler_0/tspc_2/D vssa1 3.12fF
C2670 divider_1/and_0/OUT vssa1 5.62fF
C2671 divider_1/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2672 divider_1/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2673 divider_1/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C2674 divider_1/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2675 divider_1/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2676 divider_1/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2677 divider_1/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2678 divider_1/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2679 divider_1/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2680 divider_1/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2681 divider_1/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2682 divider_1/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2683 divider_1/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2684 divider_1/prescaler_0/Out vssa1 4.59fF
C2685 divider_1/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2686 divider_1/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2687 divider_1/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2688 divider_1/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2689 divider_1/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2690 divider_1/nor_1/Z1 vssa1 1.34fF
C2691 divider_1/mc2 vssa1 5.29fF
C2692 divider_1/nor_0/Z1 vssa1 1.34fF
C2693 divider_0/and_0/Z1 vssa1 0.74fF
C2694 divider_0/and_0/B vssa1 2.25fF
C2695 divider_0/and_0/A vssa1 2.19fF
C2696 divider_0/and_0/out1 vssa1 2.93fF
C2697 divider_0/tspc_2/Z4 vssa1 0.86fF
C2698 divider_0/tspc_2/Z3 vssa1 2.26fF
C2699 divider_0/tspc_2/Z2 vssa1 1.46fF
C2700 divider_0/tspc_2/Z1 vssa1 0.99fF
C2701 divider_0/nor_0/A vssa1 7.04fF
C2702 divider_0/tspc_2/a_630_n680# vssa1 1.15fF **FLOATING
C2703 divider_0/tspc_1/Z4 vssa1 0.86fF
C2704 divider_0/tspc_1/Z3 vssa1 2.26fF
C2705 divider_0/tspc_1/Z2 vssa1 1.46fF
C2706 divider_0/tspc_1/Z1 vssa1 0.99fF
C2707 divider_0/nor_0/B vssa1 7.05fF
C2708 divider_0/tspc_1/a_630_n680# vssa1 1.15fF **FLOATING
C2709 divider_0/tspc_2/Q vssa1 3.14fF
C2710 divider_0/tspc_0/Z4 vssa1 0.86fF
C2711 divider_0/Out vssa1 1.60fF
C2712 divider_0/tspc_0/Z3 vssa1 2.26fF
C2713 divider_0/tspc_0/Z2 vssa1 1.46fF
C2714 divider_0/tspc_0/Z1 vssa1 0.99fF
C2715 divider_0/nor_1/B vssa1 6.33fF
C2716 divider_0/tspc_0/a_630_n680# vssa1 1.14fF **FLOATING
C2717 divider_0/tspc_1/Q vssa1 3.12fF
C2718 divider_0/clk vssa1 5.63fF
C2719 divider_0/prescaler_0/nand_1/z1 vssa1 0.36fF
C2720 divider_0/prescaler_0/tspc_0/D vssa1 2.64fF
C2721 divider_0/prescaler_0/tspc_2/Q vssa1 3.64fF
C2722 divider_0/prescaler_0/tspc_1/Q vssa1 3.61fF
C2723 divider_0/prescaler_0/nand_0/z1 vssa1 0.36fF
C2724 divider_0/prescaler_0/tspc_2/D vssa1 3.12fF
C2725 divider_0/and_0/OUT vssa1 5.62fF
C2726 divider_0/prescaler_0/tspc_2/Z4 vssa1 0.86fF
C2727 divider_0/prescaler_0/tspc_2/Z3 vssa1 2.26fF
C2728 divider_0/prescaler_0/tspc_2/Z2 vssa1 1.46fF
C2729 divider_0/prescaler_0/tspc_2/Z1 vssa1 0.99fF
C2730 divider_0/prescaler_0/tspc_2/a_630_n680# vssa1 1.14fF **FLOATING
C2731 divider_0/prescaler_0/tspc_2/a_740_n680# vssa1 2.11fF **FLOATING
C2732 divider_0/prescaler_0/tspc_1/Z4 vssa1 0.86fF
C2733 divider_0/prescaler_0/tspc_1/Z3 vssa1 2.26fF
C2734 divider_0/prescaler_0/tspc_1/Z2 vssa1 1.48fF
C2735 divider_0/prescaler_0/tspc_1/Z1 vssa1 0.99fF
C2736 divider_0/prescaler_0/tspc_1/a_630_n680# vssa1 1.14fF **FLOATING
C2737 divider_0/prescaler_0/m1_2700_2190# vssa1 4.22fF **FLOATING
C2738 divider_0/prescaler_0/tspc_0/Z4 vssa1 0.86fF
C2739 divider_0/prescaler_0/Out vssa1 4.59fF
C2740 divider_0/prescaler_0/tspc_0/Z3 vssa1 2.26fF
C2741 divider_0/prescaler_0/tspc_0/Z2 vssa1 1.46fF
C2742 divider_0/prescaler_0/tspc_0/Z1 vssa1 0.99fF
C2743 divider_0/prescaler_0/tspc_0/a_630_n680# vssa1 1.16fF **FLOATING
C2744 divider_0/prescaler_0/tspc_0/a_740_n680# vssa1 2.11fF **FLOATING
C2745 divider_0/nor_1/Z1 vssa1 1.34fF
C2746 divider_0/mc2 vssa1 5.29fF
C2747 divider_0/nor_0/Z1 vssa1 1.34fF
C2748 ro_complete_1/cbank_2/v vssa1 16.43fF
C2749 ro_complete_1/cbank_2/switch_5/vin vssa1 0.78fF
C2750 ro_complete_1/cbank_2/switch_4/vin vssa1 1.50fF
C2751 ro_complete_1/cbank_2/switch_2/vin vssa1 1.30fF
C2752 ro_complete_1/cbank_2/switch_3/vin vssa1 0.56fF
C2753 ro_complete_1/cbank_2/switch_1/vin vssa1 1.14fF
C2754 ro_complete_1/cbank_2/switch_0/vin vssa1 1.02fF
C2755 ro_complete_1/cbank_1/v vssa1 16.43fF
C2756 ro_complete_1/cbank_1/switch_5/vin vssa1 0.78fF
C2757 ro_complete_1/a0 vssa1 5.35fF
C2758 ro_complete_1/cbank_1/switch_4/vin vssa1 1.50fF
C2759 ro_complete_1/a1 vssa1 6.54fF
C2760 ro_complete_1/cbank_1/switch_2/vin vssa1 1.30fF
C2761 ro_complete_1/a3 vssa1 5.96fF
C2762 ro_complete_1/cbank_1/switch_3/vin vssa1 0.56fF
C2763 ro_complete_1/a2 vssa1 5.21fF
C2764 ro_complete_1/cbank_1/switch_1/vin vssa1 1.14fF
C2765 ro_complete_1/a4 vssa1 5.81fF
C2766 ro_complete_1/cbank_1/switch_0/vin vssa1 1.02fF
C2767 ro_complete_1/a5 vssa1 6.74fF
C2768 ro_complete_1/cbank_0/v vssa1 15.12fF
C2769 ro_complete_1/cbank_0/switch_5/vin vssa1 0.78fF
C2770 ro_complete_1/cbank_0/switch_4/vin vssa1 1.50fF
C2771 ro_complete_1/cbank_0/switch_2/vin vssa1 1.30fF
C2772 ro_complete_1/cbank_0/switch_3/vin vssa1 0.56fF
C2773 ro_complete_1/cbank_0/switch_1/vin vssa1 1.14fF
C2774 ro_complete_1/cbank_0/switch_0/vin vssa1 1.02fF
C2775 ro_complete_1/ro_var_extend_0/vcont vssa1 0.27fF
C2776 ro_complete_0/cbank_2/v vssa1 16.43fF
C2777 ro_complete_0/cbank_2/switch_5/vin vssa1 0.78fF
C2778 ro_complete_0/cbank_2/switch_4/vin vssa1 1.50fF
C2779 ro_complete_0/cbank_2/switch_2/vin vssa1 1.30fF
C2780 ro_complete_0/cbank_2/switch_3/vin vssa1 0.56fF
C2781 ro_complete_0/cbank_2/switch_1/vin vssa1 1.14fF
C2782 ro_complete_0/cbank_2/switch_0/vin vssa1 1.02fF
C2783 ro_complete_0/cbank_1/v vssa1 16.46fF
C2784 ro_complete_0/cbank_1/switch_5/vin vssa1 0.78fF
C2785 ro_complete_0/a0 vssa1 41.33fF
C2786 ro_complete_0/cbank_1/switch_4/vin vssa1 1.50fF
C2787 ro_complete_0/a1 vssa1 37.73fF
C2788 ro_complete_0/cbank_1/switch_2/vin vssa1 1.30fF
C2789 ro_complete_0/a3 vssa1 30.02fF
C2790 ro_complete_0/cbank_1/switch_3/vin vssa1 0.56fF
C2791 ro_complete_0/a2 vssa1 33.04fF
C2792 ro_complete_0/cbank_1/switch_1/vin vssa1 1.14fF
C2793 ro_complete_0/a4 vssa1 25.82fF
C2794 ro_complete_0/cbank_1/switch_0/vin vssa1 1.02fF
C2795 ro_complete_0/a5 vssa1 18.75fF
C2796 ro_complete_0/cbank_0/v vssa1 15.12fF
C2797 ro_complete_0/cbank_0/switch_5/vin vssa1 0.78fF
C2798 ro_complete_0/cbank_0/switch_4/vin vssa1 1.50fF
C2799 ro_complete_0/cbank_0/switch_2/vin vssa1 1.30fF
C2800 ro_complete_0/cbank_0/switch_3/vin vssa1 0.56fF
C2801 ro_complete_0/cbank_0/switch_1/vin vssa1 1.14fF
C2802 ro_complete_0/cbank_0/switch_0/vin vssa1 1.02fF
C2803 ro_complete_0/ro_var_extend_0/vcont vssa1 0.27fF
C2804 filter_0/v vssa1 109.98fF
C2805 filter_0/a_4216_n5230# vssa1 418.47fF **FLOATING
C2806 filter_0/a_4216_n2998# vssa1 1.03fF **FLOATING
C2807 cp_0/down vssa1 1.54fF
C2808 cp_0/vbias vssa1 2.41fF
C2809 cp_0/out vssa1 5.34fF
C2810 cp_0/upbar vssa1 1.50fF
C2811 cp_0/a_7110_n2840# vssa1 0.17fF **FLOATING
C2812 cp_0/a_3060_n2840# vssa1 1.71fF **FLOATING
C2813 cp_0/a_7110_0# vssa1 0.17fF **FLOATING
C2814 cp_0/a_6370_0# vssa1 0.40fF **FLOATING
C2815 cp_0/a_3060_0# vssa1 1.66fF **FLOATING
C2816 cp_0/a_1710_0# vssa1 5.89fF **FLOATING
C2817 cp_0/a_1710_n2840# vssa1 4.91fF **FLOATING
C2818 cp_0/a_10_n50# vssa1 2.96fF **FLOATING
C2819 pd_1/UP vssa1 2.21fF
C2820 pd_1/and_pd_0/Z1 vssa1 0.39fF
C2821 pd_1/and_pd_0/Out1 vssa1 2.22fF
C2822 pd_1/tspc_r_1/z5 vssa1 1.10fF
C2823 pd_1/tspc_r_1/Z4 vssa1 1.07fF
C2824 pd_1/tspc_r_1/Qbar vssa1 0.88fF
C2825 pd_1/tspc_r_1/Z2 vssa1 1.22fF
C2826 pd_1/tspc_r_1/Z1 vssa1 0.67fF
C2827 pd_1/tspc_r_1/Qbar1 vssa1 1.34fF
C2828 pd_1/tspc_r_1/Z3 vssa1 2.12fF
C2829 pd_1/REF vssa1 1.80fF
C2830 pd_1/tspc_r_0/z5 vssa1 1.10fF
C2831 pd_1/tspc_r_0/Z4 vssa1 1.07fF
C2832 pd_1/R vssa1 3.05fF
C2833 pd_1/tspc_r_0/Qbar vssa1 0.79fF
C2834 pd_1/tspc_r_0/Z2 vssa1 1.22fF
C2835 pd_1/tspc_r_0/Z1 vssa1 0.67fF
C2836 pd_1/DOWN vssa1 3.08fF
C2837 pd_1/tspc_r_0/Qbar1 vssa1 1.34fF
C2838 pd_1/tspc_r_0/Z3 vssa1 2.12fF
C2839 pd_1/DIV vssa1 1.82fF
C2840 pd_0/UP vssa1 2.21fF
C2841 pd_0/and_pd_0/Z1 vssa1 0.39fF
C2842 pd_0/and_pd_0/Out1 vssa1 2.22fF
C2843 pd_0/tspc_r_1/z5 vssa1 1.10fF
C2844 pd_0/tspc_r_1/Z4 vssa1 1.07fF
C2845 pd_0/tspc_r_1/Qbar vssa1 0.88fF
C2846 pd_0/tspc_r_1/Z2 vssa1 1.22fF
C2847 pd_0/tspc_r_1/Z1 vssa1 0.67fF
C2848 pd_0/tspc_r_1/Qbar1 vssa1 1.34fF
C2849 pd_0/tspc_r_1/Z3 vssa1 2.12fF
C2850 pd_0/REF vssa1 1.80fF
C2851 pd_0/tspc_r_0/z5 vssa1 1.10fF
C2852 pd_0/tspc_r_0/Z4 vssa1 1.07fF
C2853 pd_0/R vssa1 3.05fF
C2854 pd_0/tspc_r_0/Qbar vssa1 0.79fF
C2855 pd_0/tspc_r_0/Z2 vssa1 1.22fF
C2856 pd_0/tspc_r_0/Z1 vssa1 0.67fF
C2857 pd_0/DOWN vssa1 3.08fF
C2858 pd_0/tspc_r_0/Qbar1 vssa1 1.34fF
C2859 pd_0/tspc_r_0/Z3 vssa1 2.12fF
C2860 pd_0/DIV vssa1 1.82fF
.ends
